Properties of the parts of a building model (IFC4), part 3 of 4

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (295)
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede
 | COBERTURA SECUNDÁRIA | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 348.86 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 348.863 cm
 | COBERTURA SECUNDÁRIA | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 347.31 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 347.307 cm
 | COBERTURA SECUNDÁRIA | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 382.9 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 382.903 cm
 | COBERTURA SECUNDÁRIA | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 350.92 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 350.915 cm
3 x  | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 387.8 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 387.798 cm
2 x  | COBERTURA SECUNDÁRIA | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 47.4 | 100 mm - 4" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 47.4017 cm
2 x  | COBERTURA SECUNDÁRIA | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 22.75 | 100 mm - 4" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 22.7493 cm
9 x  | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 386.09 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 386.094 cm
 | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 378.59 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 378.594 cm
9 x  | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 72.76 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 72.765 cm
 | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 72.77 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 72.7652 cm
2 x  | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 253.57 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 253.572 cm
 | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 202.8 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 202.798 cm
 | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 427.84 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 427.844 cm
 | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 251.99 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 251.994 cm
2 x  | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 216.63 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 216.629 cm
2 x  | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 595.32 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 595.321 cm
 | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 181.35 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 181.354 cm
 | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 330.3 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 330.3 cm
 | COBERTURA SECUNDÁRIA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 444.26 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 444.256 cm
 | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 99.3 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 99.299 cm
6 x  | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 99.3 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 99.2987 cm
 | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 97.54 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 97.5422 cm
 | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 94.1 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 94.0995 cm
 | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 104.7 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 104.699 cm
10 x  | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 542.41 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 542.412 cm
2 x  | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 97.22 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 97.2226 cm
2 x  | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 286.57 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 286.566 cm
2 x  | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 96.89 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 96.8888 cm
 | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 40.26 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 40.2556 cm
 | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 288.94 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 288.943 cm
2 x  | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 338.96 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 338.958 cm
2 x  | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 107.46 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 107.463 cm
 | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 388.84 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 388.843 cm
 | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 17.05 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 17.0483 cm
34 x  | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 364.5 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 364.5 cm
 | COBERTURA | 599.4 | 15 | ø6" | 0.22 | 150 mm | 1 | 385 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 150 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 385 cm

# IfcPipeSegment: Tubos (36)
In: PAV. TÉRREO
Type - PredefinedType: RIGIDSEGMENT
Pset_AltoQi_QiBuilder - Comprimento máximo: 600 cm
Pset_Identificação_Elemento - Classe: Ferro maleável classe 10; Tipo: Tubos; Aplicação: Circular
Name | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Rede | Ferro maleável classe 10 - Tubo de aço galvanizado - 32 mm - 1.1/4" (cm)
 | 7.5 | ø3" | 0.4 | 80 mm | 69.13 | 3" | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 69.13 cm
 | 7.5 | ø3" | 0.4 | 80 mm | 907.46 | 3" | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 907.46 cm
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 555.01 | 1 1/4" | Alimentação | 555.01
 | 7.5 | ø3" | 0.4 | 80 mm | -8.19 | 3" | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": -8.19 cm
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 1.24 | 1 1/4" | Alimentação | 1.24319
2 x  | 3.2 | ø1 1/4" | 0.335 | 32 mm | 13.68 | 1 1/4" | Alimentação | 13.6768
2 x  | 3.2 | ø1 1/4" | 0.335 | 32 mm | 65.18 | 1 1/4" | Alimentação | 65.18
2 x  | 3.2 | ø1 1/4" | 0.335 | 32 mm | 12.4 | 1 1/4" | Alimentação | 12.4
2 x  | 3.2 | ø1 1/4" | 0.335 | 32 mm | 5.69 | 1 1/4" | Alimentação | 5.69
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 6.65 | 1 1/4" | Alimentação | 6.65
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 21.21 | 1 1/4" | Alimentação | 21.214
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 224.17 | 1 1/4" | Alimentação | 224.173
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 39.16 | 1 1/4" | Alimentação | 39.16
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 111.53 | 1 1/4" | Alimentação | 111.529
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 221.54 | 1 1/4" | Alimentação | 221.539
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 41.39 | 1 1/4" | Alimentação | 41.39
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 1412.59 | 1 1/4" | Alimentação | 1412.59
2 x  | 3.2 | ø1 1/4" | 0.335 | 32 mm | 7.63 | 1 1/4" | Alimentação | 7.63053
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 2.71 | 1 1/4" | Alimentação | 2.70829
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 4.67 | 1 1/4" | Alimentação | 4.67319
 | 7.5 | ø3" | 0.4 | 80 mm | 5.28 | 3" | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 80 mm - 3": 5.27846 cm
2 x  | 5 | ø2" | 0.375 | 50 mm | 4.93 | 2" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 4.92933 cm
2 x  | 5 | ø2" | 0.375 | 50 mm | 11.54 | 2" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 11.5438 cm
2 x  | 5 | ø2" | 0.375 | 50 mm | 16.54 | 2" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 16.5373 cm
 | 5 | ø2" | 0.375 | 50 mm | 11.54 | 2" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 11.5393 cm
 | 3.2 | ø1 1/4" | 0.335 | 32 mm | 5.45 | 1 1/4" | Alimentação | 5.45
 | 5 | ø2" | 0.375 | 50 mm | 3.97 | 2" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 3.97 cm
 | 5 | ø2" | 0.375 | 50 mm | 7.43 | 2" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 7.43 cm

# IfcPipeSegment: Tubos - diâmetro interno comercial (556)
In: PAV. TÉRREO
Type - PredefinedType: RIGIDSEGMENT
Pset_AltoQi_QiBuilder - Comprimento máximo: 300 cm
Pset_Identificação_Elemento - Classe: PVC rígido soldável; Tipo: Tubos - diâmetro interno comercial; Aplicação: Circular
Name | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação = Nome | Comprimento (cm) | Rede | PVC rígido soldável - Tubos - 25 mm (cm)
9 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 17.25 | Água fria | 17.25
 | 2.16 | ø3/4" | 0.17 | 25 mm | 75.58 | Água fria | 75.5831
 | 2.16 | ø3/4" | 0.17 | 25 mm | 57.82 | Água fria | 57.8169
9 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 32.62 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 32.615 cm
23 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 7 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 7 cm
14 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 23.95 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 23.95 cm
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 27.87 | Água fria | 27.8734
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 215.8 | Água fria | 215.8
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 30.5 | Água fria | 30.5032
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 134.8 | Água fria | 134.798
19 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 16.65 | Água fria | 16.65
16 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 48.5 | Água fria | 48.5
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 53.63 | Água fria | 53.6285
6 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 24.2 | Água fria | 24.2
14 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 95.7 | Água fria | 95.7
7 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 13.5 | Água fria | 13.5
6 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 65.1 | Água fria | 65.1
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 24.47 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 24.4734 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 132.6 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 132.6 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 223.34 | Água fria | 223.339
 | 2.16 | ø3/4" | 0.17 | 25 mm | 48.4 | Água fria | 48.4001
 | 2.16 | ø3/4" | 0.17 | 25 mm | 13.52 | Água fria | 13.5153
8 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 23.6 | Água fria | 23.6
 | 2.16 | ø3/4" | 0.17 | 25 mm | 127.74 | Água fria | 127.737
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 65.6 | Água fria | 65.6
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 9.62 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 9.61528 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 14.9 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 14.9 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 43.15 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 43.15 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 207.5 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 207.5 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 40.71 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 40.7095 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 15.02 | Água fria | 15.0161
5 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 80.4 | Água fria | 80.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 31 | Água fria | 31
 | 2.16 | ø3/4" | 0.17 | 25 mm | 16.6 | Água fria (Dist. Piso) | 16.5999
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 96.65 | Água fria | 96.65
16 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 135.4 | Água fria | 135.4
22 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 95.4 | Água fria | 95.4
13 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 11.65 | Água fria | 11.65
 | 2.16 | ø3/4" | 0.17 | 25 mm | 36.31 | Água fria | 36.31
4 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 32.52 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 32.515 cm
4 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 13.48 | Água fria | 13.4842
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 99.5 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 99.5 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 74.98 | Água fria | 74.9831
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 542.66 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 542.659 cm
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 88.52 | Água fria | 88.5158
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 23.15 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 23.15 cm
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 214.05 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 214.05 cm
4 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 26.65 | Água fria | 26.65
4 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 27.25 | Água fria | 27.25
6 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 136 | Água fria | 136
 | 2.16 | ø3/4" | 0.17 | 25 mm | 13.27 | Água fria | 13.2724
8 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 12.25 | Água fria | 12.25
8 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 46.45 | Água fria | 46.4515
3 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 12.78 | Água fria | 12.7756
4 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 119.97 | Água fria | 119.973
 | 2.16 | ø3/4" | 0.17 | 25 mm | 74.99 | Água fria | 74.987
 | 2.16 | ø3/4" | 0.17 | 25 mm | 12 | Água fria (Dist. Teto) | 11.9965
3 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 8.98 | Água fria | 8.97513
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 98.8 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 98.8016 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 92.33 | Água fria | 92.3265
 | 2.16 | ø3/4" | 0.17 | 25 mm | 70.9 | Água fria | 70.8978
 | 2.16 | ø3/4" | 0.17 | 25 mm | 90.08 | Água fria | 90.0799
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 134.05 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 134.05 cm
 | 7.56 | ø3" | 0.47 | 85 mm | 47.83 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 47.8309 cm
 | 7.56 | ø3" | 0.47 | 85 mm | 1000 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 999.999 cm
 | 3.52 | ø1 1/4" | 0.24 | 40 mm | 1701.18 | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 1701.18 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 1.4 | Água fria (Dist. Teto) | 1.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 336.4 | Água fria (Dist. Teto) | 336.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 241.4 | Água fria (Dist. Teto) | 241.4
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 74.6 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 74.6 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 134.7 | Água fria | 134.7
 | 2.16 | ø3/4" | 0.17 | 25 mm | 41.45 | Água fria | 41.4511
 | 2.16 | ø3/4" | 0.17 | 25 mm | 124.35 | Água fria | 124.348
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 226.5 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 226.503 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 224.27 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 224.271 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 3.4 | Água fria (Dist. Teto) | 3.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 335.4 | Água fria (Dist. Teto) | 335.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 326.4 | Água fria (Dist. Teto) | 326.4
 | 5.34 | ø2" | 0.33 | 60 mm | 5.26 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 5.26274 cm
 | 7.56 | ø3" | 0.47 | 85 mm | 63.58 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 63.576 cm
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 24.5 | Água fria (Dist. Piso) | 24.4999
 | 2.16 | ø3/4" | 0.17 | 25 mm | 9.29 | Água fria (Dist. Piso) | 9.28718
 | 2.16 | ø3/4" | 0.17 | 25 mm | 95.97 | Água fria | 95.9724
 | 2.16 | ø3/4" | 0.17 | 25 mm | 21.4 | Água fria | 21.4
4 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 30.4 | Água fria | 30.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 263.6 | Água fria (Dist. Piso) | 263.6
 | 5.34 | ø2" | 0.33 | 60 mm | 546.41 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 546.413 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 5.6 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 5.6 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 206.2 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 206.2 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 690.25 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 690.25 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 125.27 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 125.27 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 205.27 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 205.27 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 33.03 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 33.0264 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 595.9 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 595.9 cm
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 23.99 | Água fria | 23.9853
 | 5.34 | ø2" | 0.33 | 60 mm | 5.59 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 5.59 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 350.19 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 350.189 cm
6 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 32.61 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 32.615 cm
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 13.56 | Água fria | 13.5576
 | 2.16 | ø3/4" | 0.17 | 25 mm | 118.23 | Água fria | 118.225
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 32.51 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 32.515 cm
10 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 134.05 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 134.05 cm
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 44.58 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 44.5758 cm
5 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 47.9 | Água fria | 47.9
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 113.03 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 113.028 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 31.58 | Água fria | 31.5758
 | 2.16 | ø3/4" | 0.17 | 25 mm | 101.43 | Água fria | 101.428
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 133.95 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 133.95 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 102.03 | Água fria | 102.028
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 12.9 | Água fria | 12.9
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 320.14 | Água fria | 320.142
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 32.47 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 32.4675 cm
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 19.37 | Água fria | 19.3675
 | 2.16 | ø3/4" | 0.17 | 25 mm | 68.51 | Água fria | 68.5072
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 66.02 | Água fria | 66.015
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 71.03 | Água fria | 71.0272
 | 2.16 | ø3/4" | 0.17 | 25 mm | 68.51 | Água fria | 68.5075
 | 5.34 | ø2" | 0.33 | 60 mm | 72.5 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 72.5 cm
2 x  | 5.34 | ø2" | 0.33 | 60 mm | 131.69 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 131.69 cm
2 x  | 5.34 | ø2" | 0.33 | 60 mm | 211.69 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 211.69 cm
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 15.6 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 15.6 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 14.14 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 14.1424 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 14.24 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 14.2424 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 201.4 | Água fria (Dist. Teto) | 201.398
 | 2.16 | ø3/4" | 0.17 | 25 mm | 201.4 | Água fria (Dist. Teto) | 201.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 14.2 | Água fria (Dist. Teto) | 14.2
2 x  | 5.34 | ø2" | 0.33 | 60 mm | 197.5 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 197.5 cm
2 x  | 5.34 | ø2" | 0.33 | 60 mm | 210.14 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 210.138 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 106.74 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 106.737 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 178.44 | Água fria | 178.439
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 44.13 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 44.1265 cm
6 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 65.7 | Água fria | 65.7
 | 2.16 | ø3/4" | 0.17 | 25 mm | 31.57 | Água fria | 31.5689
 | 5.34 | ø2" | 0.33 | 60 mm | 5.54 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 5.54 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 271.29 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 271.289 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 14.2 | Água fria (Dist. Piso) | 14.2
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | -0.5 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | 2.16 | ø3/4" | 0.17 | 25 mm | 48.08 | Água fria | 48.0758
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 14.13 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 14.1346 cm
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 34.05 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 34.05 cm
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 26.79 | Água fria | 26.7917
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 305.8 | Água fria | 305.8
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 30.39 | Água fria | 30.3905
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 167.71 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 167.71 cm
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 77.71 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 77.71 cm
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 5.31 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 5.31348 cm
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 40.46 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 40.4551 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 18.13 | Água fria | 18.1346
 | 2.16 | ø3/4" | 0.17 | 25 mm | 2116.4 | Água fria (Dist. Piso) | 2116.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 1691.4 | Água fria (Dist. Piso) | 1691.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 84.65 | Água fria (Dist. Piso) | 84.6511
 | 2.16 | ø3/4" | 0.17 | 25 mm | 250.2 | Água fria (Dist. Piso) | 250.2
 | 5.34 | ø2" | 0.33 | 60 mm | 258.11 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 258.113 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 7.9 | Água fria (Dist. Teto) | 7.9
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 603.07 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 603.068 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 291.4 | Água fria (Dist. Teto) | 291.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 13.9 | Água fria (Dist. Teto) | 13.9
 | 2.16 | ø3/4" | 0.17 | 25 mm | 16.4 | Água fria (Dist. Teto) | 16.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 680.8 | Água fria (Dist. Teto) | 680.8
 | 2.16 | ø3/4" | 0.17 | 25 mm | 90.79 | Água fria | 90.7948
 | 2.16 | ø3/4" | 0.17 | 25 mm | 74.01 | Água fria | 74.0064
 | 2.16 | ø3/4" | 0.17 | 25 mm | 77.73 | Água fria (Dist. Teto) | 77.7266
 | 2.16 | ø3/4" | 0.17 | 25 mm | 331.4 | Água fria (Dist. Teto) | 331.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 116.25 | Água fria | 116.25
 | 2.16 | ø3/4" | 0.17 | 25 mm | 75.23 | Água fria (Dist. Teto) | 75.2266
 | 2.16 | ø3/4" | 0.17 | 25 mm | 412.69 | Água fria (Dist. Teto) | 412.691
 | 2.16 | ø3/4" | 0.17 | 25 mm | 265.11 | Água fria (Dist. Teto) | 265.109
 | 2.16 | ø3/4" | 0.17 | 25 mm | 455.07 | Água fria (Dist. Teto) | 455.073
 | 5.34 | ø2" | 0.33 | 60 mm | 1230.59 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 1230.59 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 425.44 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 425.442 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 237.5 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 237.501 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 4.04 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 4.04 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 2255.29 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 2255.29 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 2599.12 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 2599.12 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 6.26 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 6.26 cm
3 x  | 6.66 | ø2 1/2" | 0.42 | 75 mm | -0.08 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | -0.63 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 589.02 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 589.02 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 3380.29 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 3380.29 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 6.11 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 6.11 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 59.13 | Água fria | 59.1349
 | 2.16 | ø3/4" | 0.17 | 25 mm | 24.08 | Água fria (Dist. Piso) | 24.0843
 | 2.16 | ø3/4" | 0.17 | 25 mm | 406.1 | Água fria (Dist. Piso) | 406.095
 | 7.56 | ø3" | 0.47 | 85 mm | 193.4 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: 193.404 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 3393.98 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 3393.98 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 3851.78 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 3851.78 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 171.26 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 171.262 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 1293.06 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 1293.06 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 55.8 | Água fria | 55.8
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 56.12 | Água fria | 56.1244
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 53.75 | Água fria | 53.7516
 | 2.16 | ø3/4" | 0.17 | 25 mm | 128.9 | Água fria | 128.9
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 99.5 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 99.4992 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 23.5 | Água fria | 23.5
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 18.75 | Água fria | 18.75
 | 2.16 | ø3/4" | 0.17 | 25 mm | 142.65 | Água fria | 142.65
 | 2.16 | ø3/4" | 0.17 | 25 mm | 21.53 | Água fria | 21.5257
 | 2.16 | ø3/4" | 0.17 | 25 mm | 33.5 | Água fria | 33.5
 | 2.16 | ø3/4" | 0.17 | 25 mm | 88.2 | Água fria | 88.2
 | 2.16 | ø3/4" | 0.17 | 25 mm | 105.17 | Água fria | 105.168
 | 2.16 | ø3/4" | 0.17 | 25 mm | 18.65 | Água fria | 18.6482
 | 2.16 | ø3/4" | 0.17 | 25 mm | 269.45 | Água fria (Dist. Piso) | 269.45
 | 2.16 | ø3/4" | 0.17 | 25 mm | 18.6 | Água fria (Dist. Piso) | 18.6
 | 2.16 | ø3/4" | 0.17 | 25 mm | 79.45 | Água fria (Dist. Piso) | 79.45
 | 2.16 | ø3/4" | 0.17 | 25 mm | 21.4 | Água fria (Dist. Teto) | 21.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 21.4 | Água fria (Dist. Teto) | 21.4001
 | 2.16 | ø3/4" | 0.17 | 25 mm | 24.08 | Água fria (Dist. Teto) | 24.0842
 | 2.16 | ø3/4" | 0.17 | 25 mm | 165.8 | Água fria (Dist. Teto) | 165.8
 | 2.16 | ø3/4" | 0.17 | 25 mm | 393.6 | Água fria (Dist. Teto) | 393.6
 | 2.16 | ø3/4" | 0.17 | 25 mm | 24.08 | Água fria (Dist. Teto) | 24.0843
 | 2.16 | ø3/4" | 0.17 | 25 mm | 446.4 | Água fria (Dist. Teto) | 446.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 166.4 | Água fria (Dist. Teto) | 166.4
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 205.94 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 205.944 cm
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 1434.85 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 1434.85 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 80.75 | Água fria | 80.75
 | 2.16 | ø3/4" | 0.17 | 25 mm | 25.75 | Água fria | 25.75
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 29.4 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 29.4 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 76.4 | Água fria | 76.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 8.38 | Água fria | 8.37513
 | 2.16 | ø3/4" | 0.17 | 25 mm | 87.91 | Água fria | 87.915
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 29.4 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 29.4008 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 139.44 | Água fria | 139.441
 | 2.16 | ø3/4" | 0.17 | 25 mm | 48.4 | Água fria | 48.4
 | 2.16 | ø3/4" | 0.17 | 25 mm | 12.31 | Água fria | 12.3133
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 24.4 | Água fria | 24.4
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 96.5 | Água fria | 96.5
 | 2.16 | ø3/4" | 0.17 | 25 mm | 238.62 | Água fria | 238.617
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 8.41 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 8.41329 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 139.38 | Água fria | 139.385
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 9.56 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 9.55764 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 221.13 | Água fria | 221.129
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 30.6 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 30.6 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 394.2 | Água fria (Dist. Teto) | 394.2
 | 5.34 | ø2" | 0.33 | 60 mm | 257.7 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 257.7 cm
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 29.6 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 29.6 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 21.16 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 21.1593 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 31.29 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 31.2876 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 166.4 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 166.4 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 202.7 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 202.7 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 76.32 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 76.3152 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 266.69 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 266.69 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 17.45 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 17.45 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 76.69 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 76.69 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 17.5 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 17.5 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 1321.45 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 1321.45 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 211.4 | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 211.4 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 323.62 | Água fria (Dist. Teto) | 323.616
 | 6.66 | ø2 1/2" | 0.42 | 75 mm | 2553.38 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 75 mm: 2553.38 cm
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 174.99 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 174.992 cm
 | 7.56 | ø3" | 0.47 | 85 mm | -1.07 | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 85 mm: -1.07 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 22.9 | Água fria | 22.9
 | 2.16 | ø3/4" | 0.17 | 25 mm | 33.76 | Água fria | 33.7591
 | 2.16 | ø3/4" | 0.17 | 25 mm | 34.94 | Água fria | 34.9382
 | 3.52 | ø1 1/4" | 0.24 | 40 mm | 549.93 | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 549.93 cm
 | 3.52 | ø1 1/4" | 0.24 | 40 mm | 3842.73 | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 40 mm: 3842.73 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 75.59 | Água fria | 75.587
 | 2.16 | ø3/4" | 0.17 | 25 mm | 57.81 | Água fria | 57.813
2 x  | 4.4 | ø1 1/2" | 0.3 | 50 mm | 28.62 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 28.615 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 130.49 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 130.49 cm
2 x  | 5.34 | ø2" | 0.33 | 60 mm | 20.59 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 20.59 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 16.41 | Água fria | 16.4079
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 63.6 | Água fria | 63.6
2 x  | 5.34 | ø2" | 0.33 | 60 mm | 27.69 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 27.6921 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 119.04 | Água fria | 119.035
2 x  | 2.16 | ø3/4" | 0.17 | 25 mm | 132.45 | Água fria | 132.455
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 99.2 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 99.2 cm
 | 5.34 | ø2" | 0.33 | 60 mm | 131.69 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 60 mm: 131.69 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 32.89 | Água fria | 32.8921
 | 4.4 | ø1 1/2" | 0.3 | 50 mm | 100.76 | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tubos - 50 mm: 100.764 cm
 | 2.16 | ø3/4" | 0.17 | 25 mm | 107.8 | Água fria | 107.798

# IfcPump: 1.1/2" x 1.1/2" (2)
In: PAV. TÉRREO
Type - PredefinedType: VERTICALINLINE
Pset_AltoQi_QiBuilder - Modelo: Recalque - ME 2230 3CV R129 2E; Potência (CV): 3; Comprimento: 47 cm; Diâmetro: 17.2 cm; Indicação: 3CV R129 2E; Posição: Direta
Pset_Identificação_Elemento - Nome: 3CV R129 2E; Descrição: 1.1/2" x 1.1/2"; Aplicação: Bomba hidráulica; Classe: Bomba Hidráulica - Recalque; Tipo: 1.1/2" x 1.1/2"; Rede: Alimentação
Pset_AltoQi_QiBuilder-Itens_Associados - Bomba Hidráulica - Recalque - Schneider - Recalque - ME 2230 3CV: 1
Name
Bh1
Bh2

# IfcSanitaryTerminal: Bebedouro (3)
In: PAV. TÉRREO
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Indicação: 40mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 40mm; Descrição: Bebedouro; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Bebedouro; Rede: Esgoto
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm

# IfcSanitaryTerminal: Bebedouro com joelho de 90º (3)
In: PAV. TÉRREO
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.1; Indicação: BE; Posição: Direta
Pset_Identificação_Elemento - Nome: 25 mm - 1/2"; Descrição: Bebedouro com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Bebedouro com joelho de 90º; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - Aparelho - Bebedouro - 25mmx 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name
2 x 
Detalhe HID-38 (BE)

# IfcSanitaryTerminal: Chuveiro (16)
In: PAV. TÉRREO
Type - PredefinedType: SHOWER
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.1; Indicação: CH; Posição: Direta
Pset_Identificação_Elemento - Nome: 25mm x 3/4"; Descrição: Chuveiro; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Chuveiro; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - Aparelho - Chuveiro - 25mm x 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1
Name
7 x 
Detalhe HID-11 (CH)
Detalhe HID-13 (CH)
Detalhe HID-15 (CH)
Detalhe HID-27 (CH)
Detalhe HID-30 (CH)
Detalhe HID-31 (CH)
Detalhe HID-32 (CH)
Detalhe HID-34 (CH)
Detalhe HID-36 (CH)

# IfcSanitaryTerminal: Chuveiro Coletivo (2)
In: PAV. TÉRREO
Type - PredefinedType: SHOWER
Pset_AltoQi_QiBuilder - Comprimento: 18.5 cm; Diâmetro: 15 cm; Indicação: CS - 150x185x75; Posição: Direta
Pset_Identificação_Elemento - Nome: CS - 150x185x75; Descrição: Caixa sifonada (ralo); Aplicação: Caixa sifonada; Classe: PVC Esgoto; Tipo: Chuveiro Coletivo; Rede: Esgoto
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x185x75: 1

# IfcSanitaryTerminal: Chuveiro Residencial (16)
In: PAV. TÉRREO
Type - PredefinedType: SHOWER
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Chuveiro Residencial; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Chuveiro Residencial; Rede: Esgoto
Descrição do Modelo - Fabricante: Tigre ou Similar
Name | Indicação = Nome | PVC Acessórios - Ralo linear c/ grelha - 90 cm
6 x  | RL - 700x50mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo linear c/ grelha - 70 cm: 1; PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 1
10 x  | RL - 900x50mm | 1

# IfcSanitaryTerminal: Ducha Higiênica (23)
In: PAV. TÉRREO
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.2; Indicação: DH; Posição: Direta
Pset_Identificação_Elemento - Nome: 25 mm x 1/2"; Descrição: Ducha Higiênica; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Ducha Higiênica; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - Aparelho - Ducha higiênica - 25mm x 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcSanitaryTerminal: Lavatório com joelho de 90º (25)
In: PAV. TÉRREO
Type - PredefinedType: WASHHANDBASIN
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.15; Indicação: LV; Posição: Direta
Pset_Identificação_Elemento - Nome: 25 mm - 1/2"; Descrição: Lavatório com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Lavatório com joelho de 90º; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de lavatório - 25 mm - 1/2": 1; PVC Acessórios - Engate flexível plástico - 1/2 - 30cm: 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1
Name
18 x 
Detalhe HID-25 (LV)
Detalhe HID-28 (LV)
Detalhe HID-29 (LV)
Detalhe HID-33 (LV)
Detalhe HID-36 (LV)
Detalhe HID-40 (LV)
Detalhe HID-8 (LV)

# IfcSanitaryTerminal: Lavatório de Uso Geral (29)
In: PAV. TÉRREO
Type - PredefinedType: WASHHANDBASIN
Pset_AltoQi_QiBuilder - Indicação: 40mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 40mm; Descrição: Lavatório de Uso Geral; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Lavatório de Uso Geral
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 1.1/2": 1; PVC Acessórios - Válvula p/ lavatório e tanque - 1": 1; PVC Esgoto - Curva 90 curta - 40 mm: 1; PVC Esgoto - Joelho 90 c/anel p/ esgoto secundário - 40 mm - 1.1/2": 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 60 cm
Name | Rede
26 x  | Esgoto
3 x  | Esgoto (Gordura)

# IfcSanitaryTerminal: Mictório c/sifão,c/válvula de descarga,com joelho de 90º (2)
In: PAV. TÉRREO
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.5; Indicação: MIC; Posição: Direta
Pset_Identificação_Elemento - Nome: 25 mm - 3/4"; Descrição: Mictório c/sifão,c/válvula de descarga,com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Mictório c/sifão,c/válvula de descarga,com joelho de 90º; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - Aparelho - Mictório de Descarga Descontínua - 3/4": 1; Metais Pressmatic - Pressmatic mictório cromado - 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1

# IfcSanitaryTerminal: Mictório de Válvula de Descarga- DN 75mm (2)
In: PAV. TÉRREO
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Indicação: 75mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 75mm; Descrição: Mictório de Válvula de Descarga- DN 75mm; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Mictório de Válvula de Descarga- DN 75mm; Rede: Esgoto
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão flexível p/ Mictório - 1.1/4"- 2": 1; PVC Esgoto - Joelho 90 - 75 mm: 2; PVC Esgoto - Redução excêntrica - 75 mm - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 60 cm

# IfcSanitaryTerminal: Pia de Cozinha Industrial - Preparação com Sifão (18)
In: PAV. TÉRREO
Type - PredefinedType: SINK
Pset_AltoQi_QiBuilder - Indicação: 50mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 50mm; Descrição: Pia de Cozinha Industrial - Preparação com Sifão; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Pia de Cozinha Industrial - Preparação com Sifão
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 2": 1; PVC Acessórios - Válvula p/ pia - 1": 1; PVC Esgoto - Joelho 90 - 50 mm: 2; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 60 cm
Name | Rede
16 x  | Esgoto (Gordura)
2 x  | Esgoto

# IfcSanitaryTerminal: Pia de Cozinha Residencial com Sifão 50mm (3)
In: PAV. TÉRREO
Type - PredefinedType: SINK
Pset_AltoQi_QiBuilder - Indicação: 50mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 50mm; Descrição: Pia de Cozinha Residencial com Sifão 50mm; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Pia de Cozinha Residencial com Sifão 50mm
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Sifão de copo p/ pia e lavatório - 1" - 2": 1; PVC Acessórios - Válvula p/ pia - 1": 1; PVC Esgoto - Joelho 90 - 50 mm: 2; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 60 cm
Name | Rede
2 x  | Esgoto (Gordura)
 | Esgoto

# IfcSanitaryTerminal: Pia de cozinha com joelho de 90º (21)
In: PAV. TÉRREO
Type - PredefinedType: SINK
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.25; Indicação: PIA; Posição: Direta
Pset_Identificação_Elemento - Descrição: Pia de cozinha com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Pia de cozinha com joelho de 90º; Rede: Água fria
Name | Nome | Aparelho - Torneira de Pia de Cozinha - 25mm - 3/4" = PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4"
14 x  | 25 mm - 3/4" | 1
Detalhe HID-17 (PIA) | 25 mm - 3/4" | 1
Detalhe HID-18 (PIA) | 25 mm - 3/4" | 1
Detalhe HID-19 (PIA) | 25 mm - 3/4" | 1
Detalhe HID-23 (PIA) | 25 mm - 3/4" | 1
Detalhe HID-31 (PIA) | 25 mm - 3/4" | 1
2 x Detalhe HID-66 (PIA) | 25 mm - 1/2" | Pset_AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Pia de Cozinha - 25 mm - 1/2": 1; PVC soldável azul c/ bucha latão - Joelho de redução 90º soldável com bucha de latão - 25 mm- 1/2": 1

# IfcSanitaryTerminal: Tanque de lavar com joelho de 90º (5)
In: PAV. TÉRREO
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.25; Indicação: TLR; Posição: Direta
Pset_Identificação_Elemento - Nome: 25 mm - 3/4"; Descrição: Tanque de lavar com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Tanque de lavar com joelho de 90º; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Tanque de Lavar - 25mmx 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1
Name
3 x 
Detalhe HID-20 (TLR)
Detalhe HID-6 (TLR)

# IfcSanitaryTerminal: Torneira de Uso Geral com joelho de 90º (6)
In: PAV. TÉRREO
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 0.25; Indicação: TOR; Posição: Direta
Pset_Identificação_Elemento - Nome: 25 mm - 3/4"; Descrição: Torneira de Uso Geral com joelho de 90º; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Torneira de Uso Geral com joelho de 90º; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - Aparelho - Torneira de Uso Geral - 25mmx 3/4": 1; PVC soldável azul c/ bucha latão - Joelho 90º soldável com bucha de latão - 25 mm - 3/4": 1
Name
5 x 
Detalhe HID-16 (TOR)

# IfcSanitaryTerminal: Vaso Sanitário c/ curva 90º (23)
In: PAV. TÉRREO
Type - PredefinedType: WCSEAT
Pset_AltoQi_QiBuilder - Indicação: 100 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 100 mm; Descrição: Vaso Sanitário c/ curva 90º; Aplicação: Aparelho sanitário; Classe: PVC Esgoto; Tipo: Vaso Sanitário c/ curva 90º; Rede: Esgoto
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 100 mm: 1

# IfcSanitaryTerminal: Vaso Sanitário com válvula de descarga (23)
In: PAV. TÉRREO
Type - PredefinedType: WCSEAT
Pset_AltoQi_QiBuilder - Vazão de projeto (l/s): 1.7; Indicação: VS; Posição: Direta
Pset_Identificação_Elemento - Nome: 1 1/2"; Descrição: Vaso Sanitário com válvula de descarga; Aplicação: Peça de utilização; Classe: PVC rígido soldável; Tipo: Vaso Sanitário com válvula de descarga; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - Aparelho - Vaso Sanitário p/ Válvula de Descarga de 1 1/2" - 40mm - 1 1/2": 1
Name
15 x 
Detalhe HID-37 (VS)
Detalhe HID-38 (VS)
2 x Detalhe HID-4 (VS)
Detalhe HID-7 (VS)
2 x Detalhe HID-8 (VS)
Detalhe HID-9 (VS)

# IfcStackTerminal: Terminal de ventilação- coluna (15)
In: COBERTURA SECUNDÁRIA
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Terminal de ventilação- coluna; Rede: Ventilação
Name | Indicação = Nome | Descrição | PVC Esgoto - Terminal de ventilação - 50 mm
CV-1 | 50 mm | Terminal de ventilação- coluna | 1
CV-10 | 50 mm | Terminal de ventilação- coluna | 1
CV-11 | 75 mm | Terminal de ventilação - coluna | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Terminal de ventilação - 75 mm: 1
CV-12 | 50 mm | Terminal de ventilação- coluna | 1
CV-13 | 50 mm | Terminal de ventilação- coluna | 1
CV-14 | 50 mm | Terminal de ventilação- coluna | 1
CV-15 | 75 mm | Terminal de ventilação - coluna | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Terminal de ventilação - 75 mm: 1
CV-2 | 75 mm | Terminal de ventilação - coluna | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Terminal de ventilação - 75 mm: 1
CV-3 | 75 mm | Terminal de ventilação - coluna | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Terminal de ventilação - 75 mm: 1
CV-4 | 50 mm | Terminal de ventilação- coluna | 1
CV-5 | 50 mm | Terminal de ventilação- coluna | 1
CV-6 | 50 mm | Terminal de ventilação- coluna | 1
CV-7 | 50 mm | Terminal de ventilação- coluna | 1
CV-8 | 50 mm | Terminal de ventilação- coluna | 1
CV-9 | 50 mm | Terminal de ventilação- coluna | 1

# IfcTank: Tubular Fundo Reto com Divisão em Células - 70.000 L - 15,00 M, RCi1
In: PAV. TÉRREO
Type - PredefinedType: STORAGE
Pset_AltoQi_QiBuilder - Volume efetivo (l): 85000; Altura: 1500 cm; Diâmetro: 254 cm; Indicação: 70000L; Posição: Direta; % do volume do reservatório: 100; Localização: Superior; Volume da RTI (m³): 0; Volume da edificação (m³/dia): 35.4; Volume útil estimado (m³): 35.4; Volume (m³): 85; Uso do reservatório: Reservatório da água
Pset_Identificação_Elemento - Nome: 3"; Descrição: RES. TUBULAR; Aplicação: Reservatório cilíndrico; Classe: Reservatório cilíndrico; Tipo: Tubular Fundo Reto com Divisão em Células - 70.000 L - 15,00 M; Rede: Alimentação
Pset_TankTypeCommon - NominalCapacity: 85; NominalDepht: 1500 cm; NominalLenghtOrDiameter: 254 cm
Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Adapt sold. c/ flange livre p/ cx. d´água - 85 mm - 3": 1; Reservatório cilíndrico - Tubular Fundo Reto com Divisão em Células - 70.000 L - 15,00 M: 1

# IfcValve: Registro bruto de gaveta ABNT c/ FºGº (2)
In: PAV. TÉRREO
Type - PredefinedType: ISOLATING
Pset_AltoQi_QiBuilder - Indicação: RG; Posição: Direta
Pset_Identificação_Elemento - Nome: 1.1/4"; Descrição: Registro bruto de gaveta ABNT c/ FºGº; Aplicação: Registro; Classe: Ferro maleável classe 10; Tipo: Registro bruto de gaveta ABNT c/ FºGº; Rede: Alimentação
Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Niple duplo - 1.1/4": 2; Metais - Registro de gaveta bruto ABNT - 1.1/4": 1

# IfcValve: Registro bruto de gaveta industrial (4)
In: PAV. TÉRREO
Type - PredefinedType: ISOLATING
Pset_AltoQi_QiBuilder - Indicação: RG; Posição: Direta
Pset_Identificação_Elemento - Descrição: Registro bruto de gaveta industrial; Aplicação: Registro; Classe: Ferro maleável classe 10; Tipo: Registro bruto de gaveta industrial; Rede: Alimentação
Name | Nome
2 x  | 1.1/4" | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Niple duplo - 1.1/4": 2; Metais - Registro bruto de gaveta industrial - 1.1/4": 1
2 x  | 2" | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Niple duplo - 2": 2; Metais - Registro bruto de gaveta industrial - 2": 1

# IfcValve: Registro bruto gaveta Industrial c/PVC soldável (20)
In: PAV. TÉRREO
Type - PredefinedType: ISOLATING
Pset_AltoQi_QiBuilder - Indicação: RG; Posição: Direta
Pset_Identificação_Elemento - Descrição: Registro bruto gaveta Industrial c/PVC soldável; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Registro bruto gaveta Industrial c/PVC soldável
Name | Nome | Rede
4 x  | 1.1/2" | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 1.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 2
 | 3" | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 3": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 85 mm - 3": 2
4 x  | 2" | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 60 mm - 2": 2
2 x  | 2" | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 60 mm - 2": 2
2 x  | 2" | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 60 mm - 2": 2
 | 3/4" | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 3/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4": 2
 | 3" | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 3": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 85 mm - 3": 2
4 x  | 2.1/2" | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 2.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 75 mm - 2.1/2": 2
 | 2.1/2" | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro bruto de gaveta industrial - 2.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 75 mm - 2.1/2": 2

# IfcValve: Registro de Pressão com PVC soldável (14)
In: PAV. TÉRREO
Type - PredefinedType: REGULATING
Pset_AltoQi_QiBuilder - Indicação: RP; Posição: Direta
Pset_Identificação_Elemento - Nome: 25 mm - 3/4"; Descrição: Registro de Pressão com PVC soldável; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Registro de Pressão com PVC soldável; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro de pressão c/ canopla cromada - 3/4": 1; PVC misto soldável - Luva soldável c/ rosca - 25 mm -3/4": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4": 1

# IfcValve: Registro de gaveta c/canopla cromada c/PVC soldável (46)
In: PAV. TÉRREO
Type - PredefinedType: ISOLATING
Pset_AltoQi_QiBuilder - Indicação: RG; Posição: Direta
Pset_Identificação_Elemento - Descrição: Registro de gaveta c/canopla cromada c/PVC soldável; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Registro de gaveta c/canopla cromada c/PVC soldável
Name | Nome | Rede | Metais - Registro de gaveta c/ canopla cromada - 3/4" | PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 25 mm - 3/4"
9 x  | 1.1/2" | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 2
2 x  | 3/4" | Água fria (Dist. Teto) | 1 | 2
28 x  | 3/4" | Água fria | 1 | 2
4 x  | 1.1/2" | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 2
3 x  | 1.1/2" | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Registro de gaveta c/ canopla cromada - 1.1/2": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 2

# IfcValve: Registro de pressão c/ canopla cromada (2)
In: PAV. TÉRREO
Type - PredefinedType: REGULATING
Pset_AltoQi_QiBuilder - Indicação: RP; Posição: Direta
