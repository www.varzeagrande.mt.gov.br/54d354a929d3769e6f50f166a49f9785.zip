Properties of the parts of a building model (IFC4), part 4 of 4

# IfcValve: Registro de pressão c/ canopla cromada (2)
Pset_Identificação_Elemento - Nome: 3/4"; Descrição: Registro de pressão c/ canopla cromada; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Registro de pressão c/ canopla cromada; Rede: Água fria (Dist. Teto)
Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Registro de pressão c/ canopla cromada - 3/4": 1

# IfcValve: Valvula de descarga c/PVC soldável (23)
In: PAV. TÉRREO
Type - PredefinedType: FLUSHING
Pset_AltoQi_QiBuilder - Indicação: VD; Posição: Direta
Pset_Identificação_Elemento - Nome: 1.1/2"; Descrição: Valvula de descarga c/PVC soldável; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Valvula de descarga c/PVC soldável
Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Válvula de descarga baixa pressão - 1.1/2": 1; PVC Acessórios - Bolsa de ligação p/ vaso sanitário - 1.1/2": 1; PVC Acessórios - Tubo de descarga VDE. - 38 mm: 1; PVC Acessórios - Tubo de ligação latão cromado c/ canopla p/ vaso Sa. - 38 mm: 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 50 mm - 1.1/2": 1
Name | Rede
19 x  | Água fria
4 x  | Água fria (Dist. Piso)

# IfcValve: Valvula de retenção vertical c/ PVC soldável
In: PAV. TÉRREO
Type - PredefinedType: CHECK
Pset_AltoQi_QiBuilder - Indicação: VR; Posição: Direta
Pset_Identificação_Elemento - Nome: 3"; Descrição: Valvula de retenção vertical c/ PVC soldável; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Valvula de retenção vertical c/ PVC soldável; Rede: Água fria (Dist. Teto)
Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Valvula de retenção vertical - 3": 1; PVC rígido soldável - Adapt sold.curto c/bolsa-rosca p registro - 85 mm - 3": 2

# IfcValve: Válvula de descarga para mictório (2)
In: PAV. TÉRREO
Type - PredefinedType: FLUSHING
Pset_AltoQi_QiBuilder - Indicação: VDM; Posição: Direta
Pset_Identificação_Elemento - Nome: 3/4"; Descrição: Válvula de descarga p/ mictório; Aplicação: Registro; Classe: PVC rígido soldável; Tipo: Válvula de descarga para mictório; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - Metais - Válvula de descaraga p/ mictório - 3/4": 1

# IfcValve: Válvula de retençao horizontal c/ FºGº (2)
In: PAV. TÉRREO
Type - PredefinedType: CHECK
Pset_AltoQi_QiBuilder - Indicação: VR; Posição: Direta
Pset_Identificação_Elemento - Nome: 1.1/4"; Descrição: Válvula de retençao horizontal c/ FºGº; Aplicação: Registro; Classe: Ferro maleável classe 10; Tipo: Válvula de retençao horizontal c/ FºGº; Rede: Alimentação
Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Luva macho - fêmea - 1.1/4": 2; Metais - Válvula de retenção horiz c/ portinhola - 1.1/4": 1

# IfcWasteTerminal: Boca de Lobo (8)
In: PAV. TÉRREO
Type - PredefinedType: GULLYSUMP
Pset_AltoQi_QiBuilder - Comprimento: 80 cm; Largura: 40 cm; Indicação: Entrada no greide; Posição: Direta
Pset_Identificação_Elemento - Nome: Entrada no greide; Descrição: Caixa de passagem; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Boca de Lobo; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Boca de lobo para drenagem pluvial - BL- entrada greide: 1

# IfcWasteTerminal: Caixa Sifonada (23)
In: PAV. TÉRREO
Type - PredefinedType: FLOORWASTE
Pset_AltoQi_QiBuilder - Diâmetro: 15 cm; Posição: Direta
Pset_Identificação_Elemento - Descrição: Caixa Sifonada; Aplicação: Caixa sifonada; Classe: PVC Esgoto; Tipo: Caixa Sifonada; Rede: Esgoto
Name | Comprimento (cm) | Indicação = Nome | PVC Acessórios - Caixa sifonada - 150x150x50R
20 x  | 15.5 | 150x150x50R | 1
3 x  | 18.5 | 150x185x75 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Caixa sifonada - 150x185x75: 1

# IfcWasteTerminal: Caixa de areia pluvial c/grelha (4)
In: PAV. TÉRREO
Type - PredefinedType: GULLYSUMP
Pset_AltoQi_QiBuilder - Comprimento: 80 cm; Largura: 80 cm; Indicação: CAG-60x60 cm; Posição: Direta
Pset_Identificação_Elemento - Nome: CAG-60x60 cm; Descrição: Caixa de areia pluvial c/grelha; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Caixa de areia pluvial c/grelha; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de areia pluvial com grelha - CAG- 60x60cm: 1

# IfcWasteTerminal: Caixa de areia pluvial simples
In: PAV. TÉRREO
Type - PredefinedType: GULLYSUMP
Pset_AltoQi_QiBuilder - Comprimento: 100 cm; Largura: 100 cm; Indicação: CA-80x80 cm; Posição: Direta
Pset_Identificação_Elemento - Nome: CA-80x80 cm; Descrição: Caixa de areia pluvial simples; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Caixa de areia pluvial simples; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de areia pluvial sem grelha - CA- 80x80 cm: 1

# IfcWasteTerminal: Caixa de passagem (4)
In: PAV. TÉRREO
Type - PredefinedType: FLOORWASTE
Pset_AltoQi_QiBuilder - Diâmetro: 67 cm; Indicação: CE - DN 60 cm; Posição: Direta
Pset_Identificação_Elemento - Nome: CE - DN 60 cm; Descrição: Caixa de passagem; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Caixa de passagem; Rede: Esgoto (Sub-coletores)
Pset_AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de passagem modulada - DN 60 cm: 1

# IfcWasteTerminal: Caixa de passagem para águas pluviais (21)
In: PAV. TÉRREO
Type - PredefinedType: GULLYSUMP
Pset_AltoQi_QiBuilder - Comprimento: 100 cm; Largura: 100 cm; Indicação: CA-80x80 cm; Posição: Direta
Pset_Identificação_Elemento - Nome: CA-80x80 cm; Descrição: Caixa de passagem para águas pluviais; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Caixa de passagem para águas pluviais; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de passagem para águas pluviais - CA- 80x80 cm: 1

# IfcWasteTerminal: Caixas Inspeção Esgoto Sifonada (9)
In: PAV. TÉRREO
Type - PredefinedType: FLOORWASTE
Pset_AltoQi_QiBuilder - Comprimento: 80 cm; Largura: 80 cm; Indicação: CES- 60 x 60 cm; Posição: Direta
Pset_Identificação_Elemento - Nome: CES- 60 x 60 cm; Descrição: Caixas Inspeção Esgoto Sifonada; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Caixas Inspeção Esgoto Sifonada
Pset_AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de inspeção de esgoto sifonada - CES- 60x60 cm: 1
Name | Rede
8 x  | Esgoto (Sub-coletores)
 | Esgoto

# IfcWasteTerminal: Caixas Inspeção Esgoto Simples (5)
In: PAV. TÉRREO
Type - PredefinedType: FLOORWASTE
Pset_AltoQi_QiBuilder - Comprimento: 80 cm; Largura: 80 cm; Indicação: CE- 60x 60cm; Posição: Direta
Pset_Identificação_Elemento - Nome: CE- 60x 60cm; Descrição: Caixas Inspeção Esgoto Simples; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Caixas Inspeção Esgoto Simples; Rede: Esgoto (Sub-coletores)
Pset_AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de inspeção esgoto simples - CE- 60x60 cm: 1

# IfcWasteTerminal: Caixas Inspeção Esgoto com Grade (2)
In: PAV. TÉRREO
Type - PredefinedType: FLOORWASTE
Pset_AltoQi_QiBuilder - Comprimento: 80 cm; Largura: 80 cm; Indicação: CEG- 60x 60cm; Posição: Direta
Pset_Identificação_Elemento - Nome: CEG- 60x 60cm; Descrição: Caixas Inspeção Esgoto com Grade; Aplicação: Caixa de alvenaria; Classe: Caixas de Passagem; Tipo: Caixas Inspeção Esgoto com Grade; Rede: Esgoto (Sub-coletores)
Pset_AltoQi_QiBuilder-Itens_Associados - Caixas de Passagem - Caixa de inspeção esgoto com grade - CEG- 60x60 cm: 1

# IfcWasteTerminal: Calha de Piso Sifonada com Grelha Perfurada (8)
In: PAV. TÉRREO
Type - PredefinedType: FLOORTRAP
Pset_AltoQi_QiBuilder - Indicação: 130 mm x 2000 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 130 mm x 2000 mm; Descrição: Calha de Piso Sifonada com Perfurada; Aplicação: Aparelho sanitário; Classe: Calha de Piso em Aço Inox; Tipo: Calha de Piso Sifonada com Grelha Perfurada; Rede: Esgoto
Aparelho Sanitáiro - Ar Condicionado: no
Pset_AltoQi_QiBuilder-Itens_Associados - Calhas de Piso em Aço Inox - Calha de Piso Sifonada - 130 mm x 2000 mm: 1; Calhas de Piso em Aço Inox - Grelha Perfurada - 130 mm x 2000 mm: 1

# IfcWasteTerminal: Filtros (3)
In: PAV. TÉRREO
Type - PredefinedType: FLOORWASTE
Pset_AltoQi_QiBuilder - Posição: Direta; Altura do vão livre: 30 cm; Altura total do leito: 120 cm
Pset_Identificação_Elemento - Nome: Filtro anaeróbio - concreto; Aplicação: Filtro anaeróbio; Classe: Unidades de tratamento; Tipo: Filtros; Rede: Esgoto (Sub-coletores)
Name | Altura do fundo falso (cm) | Contribuição de esgoto (L/dia) | Tempo de detenção (dia) | Volume útil estimado (m³) | Volume (m³) | PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4" (cm) | PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6" (cm) | Unidades de tratamento - Brita - nº4 (m3) | Unidades de tratamento - Concreto - Concreto (m3)
FA-1 | 60 | 100 | 1 | 1 | 1.04 | 247.5 | 150 | 0.519541 | 0.054428
FA-2 | 60 | 2500 | 0.92 | 3.68 | 3.77 | 860 | 300 | 1.88496 | 0.103673
FA-3 |  | 7680 | 0.58 | 7.12704 | 7.2 | 1200 |  | 7.2 | 0.165 | Pset_AltoQi_QiBuilder - Comprimento: 300 cm; Largura: 200 cm

# IfcWasteTerminal: Ralos pluviais (41)
Type - PredefinedType: FLOORTRAP
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Ralos pluviais; Classe: PVC Esgoto; Tipo: Ralos pluviais; Rede: Pluvial
Name | In | Comprimento (cm) | Diâmetro (cm) | Indicação = Nome | Aplicação | PVC Acessórios - Ralo abacaxi - 150mm
4 x  | COBERTURA SECUNDÁRIA | 5.3 | 10 | Ralo abacaxi- 100mm | Coletor pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo abacaxi - 100mm: 1; PVC Esgoto - Joelho 90 - 100 mm: 1
AP-5 | COBERTURA SECUNDÁRIA |  |  | Ralo abacaxi- 100mm | Conexão | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo abacaxi - 100mm: 1
AP-6 | COBERTURA SECUNDÁRIA |  |  | Ralo abacaxi- 100mm | Conexão | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Acessórios - Ralo abacaxi - 100mm: 1
34 x  | COBERTURA | 15 | 10 | Ralo abacaxi- 150mm | Coletor pluvial | 1
AP-41 | COBERTURA |  |  | Ralo abacaxi- 150mm | Conexão | 1

# IfcWasteTerminal: Sumidouros (9)
In: PAV. TÉRREO
Type - PredefinedType: FLOORWASTE
Pset_AltoQi_QiBuilder - Posição: Direta; Altura da camada de brita: 30 cm; Taxa de aplicação diária (m³/m².dia): 0.05; Taxa de percolação (min/m): 700; Contribuição de esgoto (L/dia): 0
Pset_Identificação_Elemento - Nome: Circular; Aplicação: Sumidouro; Classe: Unidades de tratamento; Tipo: Sumidouros; Rede: Esgoto (Sub-coletores)
Name | Altura (cm) | PVC Esgoto - Joelho 90 - 100 mm | PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4" (cm) | Unidades de tratamento - Argamassa - Argamassa (m3) | Unidades de tratamento - Brita - nº3 (m3) | Unidades de tratamento - Tijolo - Furado
SU-1 | 100 | 1 | 50 | 0.163363 | 0.235619 | 82
SU-2 | 300 | 5 | 125 | 1.03673 | 1.47262 | 519
SU-3 | 300 | 5 | 125 | 1.03673 | 1.47262 | 519
SU-4 | 300 | 5 | 125 | 1.03673 | 1.47262 | 519
SU-5 | 300 | 5 | 125 | 1.03673 | 1.47262 | 519
SU-6 | 300 | 5 | 125 | 1.03673 | 1.47262 | 519
SU-7 | 300 | 5 | 125 | 1.03673 | 1.47262 | 519
SU-8 | 300 | 5 | 125 | 1.03673 | 1.47262 | 519
SU-9 | 300 | 5 | 125 | 1.03673 | 1.47262 | 519

# IfcWasteTerminal: Tanques sépticos (3)
In: PAV. TÉRREO
Type - PredefinedType: FLOORWASTE
Pset_AltoQi_QiBuilder - Posição: Direta; Intervalo entre limpezas: 2 anos; Número de câmaras: Câmara única; Taxa de acumul. do lodo (dias/intervalo): 105
Pset_Identificação_Elemento - Aplicação: Tanque séptico; Classe: Unidades de tratamento; Tipo: Tanques sépticos; Rede: Esgoto (Sub-coletores)
Name | Contribuição de esgoto (L/dia) | Contribuição de lodo (L/dia) | Tempo de detenção (dia) | Volume útil estimado (m³) | Profundidade útil (cm) | Volume (m³) | Nome | PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4" (cm) | Unidades de tratamento - Alça - Ferro = Unidades de tratamento - Tampa - Hermética | Unidades de tratamento - Argamassa - Argamassa (m3) | Unidades de tratamento - Tijolo - Maciço
TQ-1 | 100 | 0.4 | 1 | 1.142 | 125 | 1.19 | Tanque séptico - tijolos | 123.75 | 1 | 0.172788 | 324
TQ-2 | 2500 | 20.4 | 0.92 | 5.442 | 180 | 5.65 | Tanque séptico - tijolos | 160.6 | 1 | 0.452389 | 849
TQ-3 | 7680 | 64 | 0.58 | 12.1744 | 180 | 12.32 | Tanque séptico - concreto | 160.6 | 2 | Pset_AltoQi_QiBuilder - Comprimento: 370 cm; Largura: 185 cm; Pset_AltoQi_QiBuilder-Itens_Associados - Unidades de tratamento - Concreto - Concreto: 5.0505 m3
