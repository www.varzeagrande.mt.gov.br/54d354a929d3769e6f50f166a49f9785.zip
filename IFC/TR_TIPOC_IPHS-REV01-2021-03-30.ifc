Properties of the parts of a building model (IFC4), part 2 of 4

# IfcPipeSegment: Tubo rígido c/ ponta lisa (322)
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 95.82 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 95.821 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 29.43 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 29.4349 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 21.65 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 21.6511 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 71.72 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 71.7221 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | 0.13 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 42.93 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 42.9321 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 74.62 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 74.6165 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | -7.49 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": -7.49424 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 1 | 59.01 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 59.0066 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | 0.21 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 35.2 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 35.1966 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 80 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 80.0015 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 100 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 100.002 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | -3.13 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": -3.1309 cm
2 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 48.14 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 48.1421 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | -3.5 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": -3.49901 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 14.52 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.515 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 20.05 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 20.0487 cm
8 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 12.58 | 40 mm | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 12.5767 cm
2 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 17.36 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 17.3616 cm
2 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 1.94 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 1.94326 cm
2 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 19.86 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 19.8621 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 0.33 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
2 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | -3.01 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": -3.00753 cm
2 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 40.01 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 40.01 cm
2 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 2 | 0.77 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 14.62 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.6248 cm
4 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 2 | -0.38 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
4 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | -1 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 30.01 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 30.008 cm
3 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 14.56 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.5559 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 46.28 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 46.2799 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 26.16 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 26.1624 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 68.42 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 68.42 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 57.41 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 57.4085 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 35.36 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 35.3624 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 1 | 0.53 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 95.24 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 95.2374 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 46.03 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 46.0296 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 45.5 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 45.4991 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | -0.47 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 27.86 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 27.8616 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 130.83 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 130.829 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 56.1 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 56.1026 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 17.14 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 17.143 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 232.89 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 232.889 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 63.32 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 63.3161 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 283.23 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 283.229 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 61.84 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 61.8445 cm
2 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | -0.98 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 62.32 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 62.3223 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 284.22 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 284.223 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 62.84 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 62.8383 cm
2 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 3.59 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 3.59335 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 909.35 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 909.353 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 407.68 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 407.68 cm
2 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | -0.63 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 133.96 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 133.96 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 117.97 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 117.965 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 167.89 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 167.89 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 139.95 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 139.954 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 41.36 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 41.3579 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | -0.14 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 18.02 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 18.0205 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 46.99 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 46.9935 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 0.99 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 27.51 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 27.509 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | -0.17 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 760.54 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 760.537 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 21.79 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 21.7929 cm
2 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 66.5 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 66.5033 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 261.51 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 261.51 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 13.67 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 13.6669 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 31.12 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 31.1181 cm
2 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 5.6 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 5.60108 cm
2 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | -0.14 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 59.07 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 59.0687 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | -0.41 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 15.32 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 15.3168 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 42.01 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 42.0074 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 57.94 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 57.9422 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 40.31 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 40.3074 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 109.72 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 109.724 cm
3 x  | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 0.21 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 88.84 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 88.8401 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 177.54 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 177.537 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 204.26 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 204.258 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 35.17 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 35.1683 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 53.09 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 53.0944 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 812.84 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 812.845 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | -2.5 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": -2.4995 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 256.43 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 256.428 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 32.56 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 32.5587 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 1 | -1.9 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": -1.89925 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 7.07 | 40.36 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 40.3622 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2.14 | 71.43 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 71.4323 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 69.16 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 69.1595 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 20.53 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 20.5293 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 101.52 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 101.524 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 22.24 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 22.2372 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 1 | 0 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 13.33 | 56.7 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 56.7011 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 9.15 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 9.1547 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1.53 | 158.44 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 158.441 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 61.04 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 61.0378 cm
2 x  | PAV. TÉRREO | 15 | ø6" | 0.22 | 150 mm | 1 | 158.01 | 150 mm- 6" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 158.008 cm
 | PAV. TÉRREO | 15 | ø6" | 0.22 | 150 mm | 1 | 562.88 | 150 mm- 6" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 562.879 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 398.01 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 398.012 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | 4.4 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 4.39553 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 22.79 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 22.7865 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 3.55 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 3.5509 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 9.48 | 40.71 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 40.7116 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 483.58 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 483.581 cm
 | COBERTURA SECUNDÁRIA | 5 | ø2" | 0.16 | 50 mm | 1 | 358.51 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 358.507 cm
2 x  | COBERTURA SECUNDÁRIA | 10 | ø4" | 0.18 | 100 mm | 1 | 15 | 100 mm - 4" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 15 cm
 | COBERTURA SECUNDÁRIA | 5 | ø2" | 0.16 | 50 mm | 1 | 352.71 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 352.707 cm
 | COBERTURA SECUNDÁRIA | 5 | ø2" | 0.16 | 50 mm | 1 | 401.02 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 401.018 cm
 | COBERTURA SECUNDÁRIA | 5 | ø2" | 0.16 | 50 mm | 1 | 358.36 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 358.356 cm
 | COBERTURA SECUNDÁRIA | 5 | ø2" | 0.16 | 50 mm | 1 | 411.75 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 411.749 cm
4 x  | COBERTURA SECUNDÁRIA | 10 | ø4" | 0.18 | 100 mm | 1 | 22.7 | 100 mm - 4" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 22.7 cm
34 x  | COBERTURA | 15 | ø6" | 0.22 | 150 mm | 1 | 9.5 | 150 mm- 6" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 9.5 cm

# IfcPipeSegment: Tubo rígido c/ ponta lisa e luva simples (295)
Type - PredefinedType: RIGIDSEGMENT
Pset_Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa e luva simples; Aplicação: Circular
Name | In | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 10.85 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 10.8458 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 38.39 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 38.3853 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 2 | 490.6 | 75 mm - 3" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 490.601 cm
4 x  | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 16.56 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 16.5617 cm
4 x  | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 15.16 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 15.1616 cm
4 x  | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 16.76 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 16.7619 cm
2 x  | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 6.19 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 6.18836 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 14.19 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 14.1905 cm
2 x  | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 78.2 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 78.1973 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 25.73 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 25.7335 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 20.03 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 20.0271 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 49.14 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 49.1419 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 116.26 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 116.262 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 129.84 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 129.836 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 99.83 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 99.8305 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 133.4 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 133.399 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 34.71 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 34.7075 cm
3 x  | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 17.2 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 17.204 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 168.8 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 168.796 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 539.49 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 539.492 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 429.96 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 429.958 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 43.52 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 43.5175 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 23.01 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 23.0119 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 98.41 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 98.4132 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 106.49 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 106.492 cm
2 x  | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 121.69 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 121.689 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 67.85 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 67.8474 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 43.87 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 43.8687 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 25.74 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 25.7378 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 547.14 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 547.14 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 40.97 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 40.9667 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 735.4 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 735.404 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 28.81 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 28.8071 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 7.54 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 7.53906 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 571.31 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 571.312 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 218.79 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 218.79 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 29.64 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 29.6409 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 715.44 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 715.437 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 32.43 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 32.4349 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 14.8 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 14.8012 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 2 | 333.12 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 333.122 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 82.66 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 82.6579 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 52.73 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 52.7296 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 796.44 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 796.436 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 34.04 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 34.0394 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 39.53 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 39.5262 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 2 | 64.9 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 64.8973 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 2 | 31.81 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 31.8102 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 38.4 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 38.4029 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 2 | 66.8 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 66.7973 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 90.52 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 90.5179 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 146.21 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 146.208 cm
2 x  | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 2 | 201.15 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 201.146 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 192.09 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 192.094 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 192.78 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 192.782 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 71.52 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 71.518 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 29.01 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 29.0075 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 8.93 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 8.92517 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 167.53 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 167.533 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 49.62 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 49.6244 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 27.83 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 27.8262 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 39.95 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 39.9538 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 0.35 | 24.36 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 24.3589 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 70.7 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 70.7048 cm
2 x  | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 4.81 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 4.81429 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 11.34 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 11.3417 cm
3 x  | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 27.86 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 27.8616 cm
3 x  | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 27.51 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 27.5101 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 678.83 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 678.83 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 2 | 10.77 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 10.773 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 17.51 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 17.5081 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 553 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 552.999 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 679.83 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 679.83 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 260.22 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 260.222 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 531.64 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 531.642 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 11.82 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 11.8189 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 301.9 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 301.9 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 183.45 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 183.447 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 63.95 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 63.95 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 430.21 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 430.206 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 80.95 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 80.9503 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 6.34 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 6.33638 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 187.39 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 187.39 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 68.86 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 68.8641 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 386.57 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 386.571 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 104.84 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 104.842 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 40.01 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 40.01 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 2 | 0.77 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 17.12 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 17.1222 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 260.93 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 260.927 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 431.96 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 431.959 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 168.3 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 168.3 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 24.33 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 24.3333 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 394.05 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 394.047 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 621.72 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 621.717 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 635.81 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 635.808 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 11.53 | 50.69 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 50.6901 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 430.14 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 430.143 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 36.48 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 36.4846 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 10.22 | 61.74 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 61.7447 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 3.29 | 259.89 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 259.893 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 5.38 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 5.38485 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 14.9 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 14.8999 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 37.82 | 70.27 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 70.2701 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 155.88 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 155.883 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 121.55 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 121.552 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 103.99 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 103.993 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 261.64 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 261.636 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 260.93 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 260.931 cm
2 x  | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 24.16 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 24.16 cm
2 x  | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 309.3 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 309.298 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 312.3 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 312.304 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 334.38 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 334.382 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 11.84 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 11.8406 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 5.58 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 5.57907 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 55.96 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 55.9642 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 41.32 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 41.3249 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 241.04 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 241.037 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 2 | 83.52 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 83.5211 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 2 | 99.04 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 99.0377 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 16.61 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 16.6059 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 30.76 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 30.7638 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 172.19 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 172.187 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 13.05 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 13.0468 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 97.08 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 97.0833 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 31.19 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 31.1881 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 5.49 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 5.48569 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 21.23 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 21.2328 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 24.83 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 24.8348 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 41.6 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 41.6028 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 23.37 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 23.374 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 186.99 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 186.994 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 603.99 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 603.986 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 603.99 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 603.989 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 529.05 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 529.05 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 80.64 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 80.6401 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 25.36 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 25.364 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 26.97 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 26.9683 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 62.02 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 62.0178 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 129.48 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 129.482 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 97.53 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 97.534 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 32.77 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 32.7681 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 30.88 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 30.8847 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 150.42 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 150.421 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 58.81 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 58.8082 cm
 | PAV. TÉRREO | 296.5 | 5 | ø2" | 0.16 | 50 mm | 2 | 45.09 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 45.0944 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 269.34 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 269.345 cm
 | PAV. TÉRREO | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 69.4 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 69.4041 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 737.4 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 737.398 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 717.71 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 717.707 cm
 | PAV. TÉRREO | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 526.59 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 526.588 cm
2 x  | COBERTURA SECUNDÁRIA | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 261.37 | 100 mm - 4" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 261.368 cm
2 x  | COBERTURA SECUNDÁRIA | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 420.01 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 420.007 cm
2 x  | COBERTURA SECUNDÁRIA | 295.1 | 10 | ø4" | 0.18 | 100 mm | 1 | 278.8 | 100 mm - 4" | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 100 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 278.8 cm
 | COBERTURA SECUNDÁRIA | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 424.96 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 424.961 cm
 | COBERTURA SECUNDÁRIA | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 388.25 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 388.251 cm
 | COBERTURA SECUNDÁRIA | 296.5 | 5 | ø2" | 0.16 | 50 mm | 1 | 387.36 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 50 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 387.365 cm
 | COBERTURA SECUNDÁRIA | 296.1 | 7.5 | ø3" | 0.17 | 75 mm | 1 | 345.04 | 75 mm - 3" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva simples - 75 mm: 1; PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 345.039 cm
