Properties of the parts of a building model (IFC4), part 1 of 4

# File
Description: IFC4
Time: 2022-05-03T14:47:28
Made in: IfcPlusPlus

# IfcBuildingStorey (3)
Name | LongName | Elevation (cm)
PAV. TÉRREO | PAV. TÉRREO | 20
COBERTURA SECUNDÁRIA | COBERTURA SECUNDÁRIA | 335
COBERTURA | COBERTURA | 720

# IfcFlowMeter: Alimentador Predial
In: PAV. TÉRREO
Type - PredefinedType: WATERMETER
Pset_AltoQi_QiBuilder - Indicação: 1 1/4"; Posição: Direta
Pset_Identificação_Elemento - Nome: 1 1/4"; Descrição: Alimentador Predial; Aplicação: Alimentador predial; Classe: Ferro maleável classe 10; Tipo: Alimentador Predial; Rede: Alimentação
Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Colar de tomada de fºfº - 1 1/4": 1; Ferro maleável classe 10 - Luva macho - fêmea - 1.1/4": 3; Metais - Registro de esfera - 1 1/4": 2

# IfcFlowMeter: Hidrômetro
In: PAV. TÉRREO
Type - PredefinedType: WATERMETER
Pset_AltoQi_QiBuilder - Indicação: HIDRÔMETRO; Posição: Direta
Pset_Identificação_Elemento - Nome: cavalete 1.1/4"; Descrição: Hidrômetros; Aplicação: Hidrômetro principal; Classe: Ferro maleável classe 10; Tipo: Hidrômetro; Rede: Alimentação
Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Bucha de redução - 1" x 3/4": 1; Ferro maleável classe 10 - Bucha de redução - 2" x 1.1/4": 2; Ferro maleável classe 10 - Bujão - 3/4": 1; Ferro maleável classe 10 - Contraporca - 2": 1; Ferro maleável classe 10 - Cotovelo 90 - 1.1/4": 2; Ferro maleável classe 10 - Curva macho - 1.1/4": 4; Ferro maleável classe 10 - Luva - 1.1/4": 2; Ferro maleável classe 10 - Luva - 2": 2; Ferro maleável classe 10 - Tubo de aço galvanizado - 32 mm - 1.1/4": 172 cm; Ferro maleável classe 10 - Tubo de aço galvanizado - 40 mm - 1.1/2": 35 cm; Ferro maleável classe 10 - Tubo de aço galvanizado - 50 mm - 2": 30 cm; Ferro maleável classe 10 - Tê de redução - 2" x 1": 1; Ferro maleável classe 10 - União ass. cônico de bronze/ferro - 1.1/4": 2; Metais - Registro de gaveta bruto ABNT - 1.1/4": 1

# IfcInterceptor: Caixa de gordura (6)
In: PAV. TÉRREO
Type - PredefinedType: OIL
Pset_AltoQi_QiBuilder - Indicação: CGD; Posição: Direta; Altura sobressalente: 25 cm
Pset_Identificação_Elemento - Nome: Tijolo; Descrição: CGD; Aplicação: Caixa de gordura; Classe: Unidades de tratamento; Tipo: Caixa de gordura; Rede: Esgoto (Gordura)
Pset_AltoQi_QiBuilder-Itens_Associados - Unidades de tratamento - Alça - Ferro: 1; Unidades de tratamento - Tijolo - Maciço: 1
Name | Número de cozinhas | Tipo de caixa | Volume estimado de retenção (l) | Profundidade útil (cm) | Volume de retenção (l) | Unidades de tratamento - Argamassa - Argamassa (m3)
CG-1 | Duas cozinhas | Simples (CGS) | 31 | 25 | 31.4 | 0.025133
CG-2 | Mais de 12 cozinhas ou restaurantes | Especial (CGE) | 420 | 60 | 432 | 0.1224 | Pset_AltoQi_QiBuilder - Comprimento: 120 cm; Largura: 60 cm
CG-3 | Mais de 12 cozinhas ou restaurantes | Especial (CGE) | 420 | 60 | 432 | 0.1224 | Pset_AltoQi_QiBuilder - Comprimento: 120 cm; Largura: 60 cm
CG-4 | Uma cozinha | Simples (CGS) | 31 | 25 | 31.4 | 0.025133
CG-5 | Uma cozinha | Simples (CGS) | 31 | 25 | 31.4 | 0.025133
CG-6 | Uma cozinha | Simples (CGS) | 31 | 25 | 31.4 | 0.025133

# IfcPipeFitting: Bucha de redução longa (8)
In: PAV. TÉRREO
Type - PredefinedType: TRANSITION
Pset_AltoQi_QiBuilder - Indicação: 50 mm - 40 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 50 mm - 40 mm; Descrição: Bucha de redução longa; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Bucha de redução longa; Rede: Esgoto (Gordura)
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 1

# IfcPipeFitting: Bucha de redução longa - Amanco
In: PAV. TÉRREO
Type - PredefinedType: TRANSITION
Pset_AltoQi_QiBuilder - Indicação: 50 mm - 40 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 50 mm - 40 mm; Descrição: Bucha de redução longa; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Bucha de redução longa - Amanco; Rede: Esgoto
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 1

# IfcPipeFitting: Bucha de redução sold. longa (2)
In: PAV. TÉRREO
Type - PredefinedType: TRANSITION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Bucha de redução sold. longa; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Bucha de redução sold. longa; Rede: Água fria (Dist. Teto)
Name | Indicação = Nome
 | 50 mm - 25 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 25 mm: 1
 | 60 mm - 25 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 60 mm - 25 mm: 1

# IfcPipeFitting: Cabeceira retangular (13)
In: COBERTURA
Type - PredefinedType: EXIT
Pset_AltoQi_QiBuilder - Indicação: 250 mm x 500 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 250 mm x 500 mm; Descrição: Cabeceira retangular; Aplicação: Conexão; Classe: Calha metálica; Tipo: Cabeceira retangular; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento

# IfcPipeFitting: Cotovelo 90 (14)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Cotovelo 90; Aplicação: Conexão; Classe: Ferro maleável classe 10; Tipo: Cotovelo 90
Name | Indicação = Nome | Rede
3 x  | 2" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 2": 1
4 x  | 3" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 3": 1
 | 4" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 4": 1
3 x  | 1.1/4" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 1.1/4": 1
AFt-5 | 3" | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 3": 1
AL-1 | 1.1/4" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 1.1/4": 1
REC-1 | 1.1/4" | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Cotovelo 90 - 1.1/4": 1

# IfcPipeFitting: Cruzeta soldável (2)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Indicação: 25 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 25 mm; Descrição: Cruzeta soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Cruzeta soldável; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Cruzeta soldável - 25 mm: 1

# IfcPipeFitting: Curva 45 Longa para Esgoto Sanitário (60)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Curva 45 Longa para Esgoto Sanitário; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Curva 45 Longa para Esgoto Sanitário
Name | Indicação = Nome | Rede | PVC Esgoto - Curva 45 longa - 50 mm
7 x  | 100 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 45 longa - 100 mm: 1
10 x  | 50mm | Esgoto | 1
7 x  | 75mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 45 longa - 75 mm: 1
15 x  | 50mm | Ventilação | 1
15 x  | 50mm | Esgoto (Gordura) | 1
5 x  | 150mm | Pluvial | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 45 longa - 150 mm: 1
 | 75mm | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 45 longa - 75 mm: 1

# IfcPipeFitting: Curva 45 Longa para Esgoto Sanitário- desce (34)
In: COBERTURA
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Indicação: 150mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 150mm; Descrição: Curva 45 Longa para Esgoto Sanitário- desce; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Curva 45 Longa para Esgoto Sanitário- desce; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 45 longa - 150 mm: 1
Name
AP-10
AP-11
AP-12
AP-13
AP-14
AP-15
AP-16
AP-17
AP-18
AP-19
AP-20
AP-21
AP-22
AP-23
AP-24
AP-25
AP-26
AP-27
AP-28
AP-29
AP-30
AP-31
AP-32
AP-33
AP-34
AP-35
AP-36
AP-37
AP-38
AP-39
AP-40
AP-7
AP-8
AP-9

# IfcPipeFitting: Curva 45 Longa para Esgoto Sanitário- sobe (34)
In: COBERTURA
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Indicação: 150mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 150mm; Descrição: Curva 45 Longa para Esgoto Sanitário- sobe; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Curva 45 Longa para Esgoto Sanitário- sobe; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 45 longa - 150 mm: 1

# IfcPipeFitting: Curva 45 longa Amanco (21)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Indicação: 40 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 40 mm; Descrição: Curva 45 longa Amanco; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Curva 45 longa Amanco; Rede: Esgoto
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 45 longa Amanco - 40 mm: 1

# IfcPipeFitting: Curva 90 curta (4)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Indicação: 50 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 50 mm; Descrição: Curva 90 curta; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Curva 90 curta; Rede: Esgoto (Gordura)
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 50 mm: 1

# IfcPipeFitting: Curva 90 curta- coluna (15)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Curva 90 curta- coluna; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Curva 90 curta- coluna; Rede: Ventilação
Name | Indicação = Nome | PVC Esgoto - Curva 90 curta - 50 mm
CV-1 | 50 mm | 1
CV-10 | 50 mm | 1
CV-11 | 75 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 75 mm: 1
CV-12 | 50 mm | 1
CV-13 | 50 mm | 1
CV-14 | 50 mm | 1
CV-15 | 75 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 75 mm: 1
CV-2 | 75 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 75 mm: 1
CV-3 | 75 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 75 mm: 1
CV-4 | 50 mm | 1
CV-5 | 50 mm | 1
CV-6 | 50 mm | 1
CV-7 | 50 mm | 1
CV-8 | 75 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Curva 90 curta - 75 mm: 1
CV-9 | 50 mm | 1

# IfcPipeFitting: Curva de transposição (20)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Indicação: CT; Posição: Direta
Pset_Identificação_Elemento - Nome: 25 mm; Descrição: Curva de transposição; Aplicação: Curva de transposição; Classe: PVC rígido soldável; Tipo: Curva de transposição; Rede: Água fria
Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Curva de transposição - 25 mm: 1

# IfcPipeFitting: Joelho 45 (13)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Joelho 45; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Joelho 45
Name | Indicação = Nome | Rede | PVC Esgoto - Joelho 45 - 40 mm
7 x  | 40 mm | Esgoto | 1
4 x  | 100 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1
2 x  | 50 mm | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 50 mm: 1

# IfcPipeFitting: Joelho 45 soldável (7)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Joelho 45 soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Joelho 45 soldável
Name | Indicação = Nome | Rede
 | 60 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 60 mm: 1
2 x  | 25 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 25 mm: 1
 | 25 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 25 mm: 1
2 x  | 50 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 50 mm: 1
 | 75 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 45 soldável - 75 mm: 1

# IfcPipeFitting: Joelho 45- desce (4)
In: COBERTURA SECUNDÁRIA
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Indicação: 100 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 100 mm; Descrição: Joelho 45- desce; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Joelho 45- desce; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1
Name
AP-1
AP-2
AP-3
AP-4

# IfcPipeFitting: Joelho 45- sobe (4)
In: COBERTURA SECUNDÁRIA
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Indicação: 100 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 100 mm; Descrição: Joelho 45- sobe; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Joelho 45- sobe; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 45 - 100 mm: 1

# IfcPipeFitting: Joelho 45º Serie R
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Indicação: 150 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 150 mm; Descrição: Joelho 45º Serie R; Aplicação: Conexão; Classe: PVC série R; Tipo: Joelho 45º Serie R; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - PVC série R - Joelho 45º Série R - 150 mm: 1

# IfcPipeFitting: Joelho 90 soldável (176)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Joelho 90 soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Joelho 90 soldável
Name | Indicação = Nome | Rede | PVC rígido soldável - Joelho 90º soldável - 25 mm
96 x  | 25 mm | Água fria | 1
15 x  | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
2 x  | 40 mm | Alimentação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 40 mm: 1
3 x  | 60 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
7 x  | 50 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
2 x  | 50 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
2 x  | 75 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 75 mm: 1
2 x  | 85 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 85 mm: 1
3 x  | 25 mm | Água fria (Dist. Teto) | 1
 | 25 mm | Água fria (Dist. Piso) | 1
AF-1 | 25 mm | Água fria | 1
AF-10 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-11 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-12 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-13 | 25 mm | Água fria | 1
AF-14 | 25 mm | Água fria | 1
AF-15 | 25 mm | Água fria | 1
AF-17 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-18 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-2 | 25 mm | Água fria | 1
AF-20 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-21 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-27 | 25 mm | Água fria | 1
AF-29 | 25 mm | Água fria | 1
AF-3 | 25 mm | Água fria | 1
AF-30 | 25 mm | Água fria | 1
AF-31 | 25 mm | Água fria | 1
AF-32 | 25 mm | Água fria | 1
AF-33 | 25 mm | Água fria | 1
AF-34 | 25 mm | Água fria | 1
AF-36 | 25 mm | Água fria | 1
AF-37 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-39 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-4 | 25 mm | Água fria | 1
AF-40 | 25 mm | Água fria | 1
AF-41 | 25 mm | Água fria | 1
AF-42 | 25 mm | Água fria | 1
AF-43 | 60 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
AF-44 | 25 mm | Água fria | 1
AF-5 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-6 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AF-7 | 25 mm | Água fria | 1
AF-8 | 25 mm | Água fria | 1
AF-9 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AFt-1 | 60 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
AFt-10 | 75 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 75 mm: 1
AFt-2 | 25 mm | Água fria (Dist. Piso) | 1
AFt-3 | 50 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AFt-4 | 50 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AFt-6 | 60 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
AFt-7 | 60 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 60 mm: 1
AFt-8 | 50 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1
AFt-9 | 50 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Joelho 90º soldável - 50 mm: 1

# IfcPipeFitting: Joelho 90º Serie R coluna (39)
In: PAV. TÉRREO
Type - PredefinedType: BEND
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Joelho 90º Serie R coluna; Aplicação: Conexão; Classe: PVC série R; Tipo: Joelho 90º Serie R coluna; Rede: Pluvial
Name | Indicação = Nome | PVC série R - Joelho 90º Série R - 150 mm
AP-1 | 100 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC série R - Joelho 90º Série R - 100 mm: 1
AP-10 | 150 mm | 1
AP-11 | 150 mm | 1
AP-12 | 150 mm | 1
AP-13 | 150 mm | 1
AP-14 | 150 mm | 1
AP-15 | 150 mm | 1
AP-16 | 150 mm | 1
AP-17 | 150 mm | 1
AP-18 | 150 mm | 1
AP-19 | 150 mm | 1
AP-2 | 100 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC série R - Joelho 90º Série R - 100 mm: 1
AP-20 | 150 mm | 1
AP-21 | 150 mm | 1
AP-22 | 150 mm | 1
AP-23 | 150 mm | 1
AP-24 | 150 mm | 1
AP-25 | 150 mm | 1
AP-26 | 150 mm | 1
AP-27 | 150 mm | 1
AP-28 | 150 mm | 1
AP-29 | 150 mm | 1
AP-3 | 100 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC série R - Joelho 90º Série R - 100 mm: 1
AP-30 | 150 mm | 1
AP-31 | 150 mm | 1
AP-32 | 150 mm | 1
AP-33 | 150 mm | 1
AP-34 | 150 mm | 1
AP-35 | 150 mm | 1
AP-36 | 150 mm | 1
AP-37 | 150 mm | 1
AP-38 | 150 mm | 1
AP-39 | 150 mm | 1
AP-4 | 100 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC série R - Joelho 90º Série R - 100 mm: 1
AP-40 | 150 mm | 1
AP-41 | 150 mm | 1
AP-7 | 150 mm | 1
AP-8 | 150 mm | 1
AP-9 | 150 mm | 1

# IfcPipeFitting: Junção simples (68)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Junção simples; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Junção simples
Name | Indicação = Nome | Rede
16 x  | 100 mm - 50 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
13 x  | 100 mm- 100 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
11 x  | 40 mm x 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 40 mm x 40 mm: 1
8 x  | 50 mm - 50 mm | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
5 x  | 75 mm - 50 mm | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm - 50 mm: 1
8 x  | 100 mm - 50 mm | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1
4 x  | 100 mm- 100 mm | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm- 100 mm: 1
 | 75 mm 75 mm | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm 75 mm: 1
2 x  | 100 mm - 75 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 75 mm: 1

# IfcPipeFitting: Junção simples c/ redução (21)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Junção simples c/ redução; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Junção simples c/ redução
Name | Indicação | Nome | Rede
2 x  | 100 mm - 75 mm(75-75) | 100 mm - 75 mm(75-75) | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 75 mm: 1; PVC Esgoto - Redução excêntrica - 100 mm - 75 mm: 1
5 x  | 75 mm - 50 mm(50-50) | 75 mm - 50 mm(50-50) | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm - 50 mm: 1; PVC Esgoto - Redução excêntrica - 75 mm - 50 mm: 1
 | 50 mm - 50 mm(40-50) | 50 mm - 50 mm (40-50) | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 1; PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
8 x  | 100 mm - 50 mm(50-50) | 100 mm - 50 mm(50-50) | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 100 mm - 50 mm: 1; PVC Esgoto - Redução excêntrica - 100 mm - 50 mm: 1
 | 50 mm - 50 mm(40-40) | 50 mm - 50 mm(40-40) | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Bucha de redução longa - 50 mm - 40 mm: 2; PVC Esgoto - Junção simples - 50 mm - 50 mm: 1
3 x  | 75 mm - 75 mm(75-50) | 75 mm - 75 mm (75-50) | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Junção simples - 75 mm - 50 mm: 1; PVC Esgoto - Redução excêntrica - 75 mm - 50 mm: 1
 | 100 mm- 100 mm(100-50) | 100 mm- 100 mm(100-50) | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Redução excêntrica - 100 mm - 50 mm: 1; PVC Esgoto - Junção simples - 100 mm- 100 mm: 1

# IfcPipeFitting: Luva de correr- coluna (35)
In: COBERTURA SECUNDÁRIA
Type - PredefinedType: CONNECTOR
Pset_AltoQi_QiBuilder - Indicação: 150 mm; Posição: Direta
Pset_Identificação_Elemento - Nome: 150 mm; Descrição: Luva de correr- coluna; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Luva de correr- coluna; Rede: Pluvial
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Luva de correr - 150 mm: 1
Name
AP-10
AP-11
AP-12
AP-13
AP-14
AP-15
AP-16
AP-17
AP-18
AP-19
AP-20
AP-21
AP-22
AP-23
AP-24
AP-25
AP-26
AP-27
AP-28
AP-29
AP-30
AP-31
AP-32
AP-33
AP-34
AP-35
AP-36
AP-37
AP-38
AP-39
AP-40
AP-41
AP-7
AP-8
AP-9

# IfcPipeFitting: Ramais de Ventilação (42)
In: PAV. TÉRREO
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Aplicação: Ramal de ventilação; Classe: PVC Esgoto; Tipo: Ramais de Ventilação
Name | Indicação = Nome | Descrição | Rede | PVC Esgoto - Joelho 90 - 50 mm
 | 75mm- 50mm-135º | Ramais de Ventilação | Ventilação | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 75 mm - 50 mm: 1
6 x  | 50mm-50mm-45º | Ramais de Ventilação | Ventilação | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
2 x  | 100mm - 50mm-135° | Ramais de ventilação | Ventilação | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
9 x  | 50mm-50mm-90º | Ramais de Ventilação | Ventilação | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
4 x  | 75mm- 50mm-90º | Ramais de Ventilação | Ventilação | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 75 mm - 50 mm: 1
4 x  | 100mm - 50mm-45° | Ramais de ventilação | Ventilação | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
 | 100mm- 75mm-90º | Ramais de Ventilação | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 75 mm: 1; PVC Esgoto - Tê sanitário - 100 mm - 75 mm: 1
 | 50mm-50mm-45º | Ramais de Ventilação | Esgoto | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
7 x  | 100mm - 50mm-90° | Ramais de ventilação | Ventilação | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
 | 50mm-50mm-0º | Ramais de Ventilação | Esgoto | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
2 x  | 100mm - 50mm-0° | Ramais de Ventilação | Ventilação | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1
3 x  | 50mm-50mm-135º | Ramais de Ventilação | Ventilação | 1 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
 | 75mm- 75mm-45º | Ramais de Ventilação | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Joelho 90 - 75 mm: 1; PVC Esgoto - Tê sanitário - 75 mm - 75 mm: 1

# IfcPipeFitting: Ramais de ventilação em cruz
In: PAV. TÉRREO
Type - PredefinedType: USERDEFINED
Pset_AltoQi_QiBuilder - Indicação: 100mm x 50mm - 135°; Posição: Direta
Pset_Identificação_Elemento - Nome: 100mm x 50mm - 135°; Descrição: Ramais de Ventilação em Cruz; Aplicação: Ramal de ventilação; Classe: PVC Esgoto; Tipo: Ramais de ventilação em cruz; Rede: Ventilação
Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 100 mm - 50 mm: 1; PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1

# IfcPipeFitting: Redução excêntrica- superior (3)
In: PAV. TÉRREO
Type - PredefinedType: TRANSITION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Redução excêntrica- superior; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Redução excêntrica- superior
Name | Indicação = Nome | Rede | PVC Esgoto - Redução excêntrica - 75 mm - 50 mm
 | 100 mm - 50 mm | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Redução excêntrica - 100 mm - 50 mm: 1
 | 75 mm - 50 mm | Esgoto | 1
 | 75 mm - 50 mm | Ventilação | 1

# IfcPipeFitting: Te (2)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Te; Aplicação: Conexão; Classe: Ferro maleável classe 10; Tipo: Te; Rede: Alimentação
Name | Indicação = Nome
 | 4" | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tê - 4": 1
 | 1.1/4" | Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Tê - 1.1/4": 1

# IfcPipeFitting: Te 90 soldável (61)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Te 90 soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Te 90 soldável
Name | Indicação = Nome | Rede | PVC rígido soldável - Tê 90 soldável - 25 mm
45 x  | 25 mm | Água fria | 1
4 x  | 25 mm | Água fria (Dist. Teto) | 1
5 x  | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 50 mm: 1
AF-16 | 25 mm | Água fria | 1
AF-19 | 25 mm | Água fria | 1
AF-22 | 50 mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 50 mm: 1
AF-24 | 25 mm | Água fria | 1
AF-25 | 25 mm | Água fria | 1
AF-26 | 25 mm | Água fria | 1
AF-28 | 25 mm | Água fria | 1

# IfcPipeFitting: Te 90 soldável (centro) (8)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Te 90 soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Te 90 soldável (centro)
Name | Indicação = Nome | Rede | PVC rígido soldável - Tê 90 soldável - 25 mm
 | 25 mm | Água fria (Dist. Piso) | 1
 | 25 mm | Água fria (Dist. Teto) | 1
5 x  | 25 mm | Água fria | 1
 | 60 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 60 mm: 1

# IfcPipeFitting: Te 90 soldável c/ redução central (4)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Te 90 soldável c/ redução central; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Te 90 soldável c/ redução central
Name | Indicação = Nome | Rede
 | 60 mm - 25 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 60 mm - 25 mm: 1; PVC rígido soldável - Tê 90 soldável - 60 mm: 1
 | 60 mm - 25 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 60 mm - 25 mm: 1; PVC rígido soldável - Tê 90 soldável - 60 mm: 1
 | 75 mm - 25 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 25 mm: 1; PVC rígido soldável - Bucha de redução sold. longa - 75 mm - 50 mm: 1; PVC rígido soldável - Tê 90 soldável - 75 mm: 1
 | 75 mm - 25 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 25 mm: 1; PVC rígido soldável - Bucha de redução sold. longa - 75 mm - 50 mm: 1; PVC rígido soldável - Tê 90 soldável - 75 mm: 1

# IfcPipeFitting: Te 90 soldável c/ redução lateral (25)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Te 90 soldável c/ redução lateral; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Te 90 soldável c/ redução lateral
Name | Indicação = Nome | Rede | PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 25 mm = PVC rígido soldável - Tê 90 soldável - 50 mm
15 x  | 50 mm- 25mm | Água fria | 1
2 x  | 60 mm- 25mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 60 mm - 25 mm: 1; PVC rígido soldável - Tê 90 soldável - 60 mm: 1
2 x  | 60 mm- 50mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 60 mm: 1; PVC rígido soldável - Bucha de redução sold. curta - 60 mm - 50 mm: 1
3 x  | 60 mm- 25mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 60 mm - 25 mm: 1; PVC rígido soldável - Tê 90 soldável - 60 mm: 1
 | 75 mm- 50mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 75 mm - 50 mm: 1; PVC rígido soldável - Tê 90 soldável - 75 mm: 1
AF-23 | 50 mm- 25mm | Água fria | 1
AF-35 | 75 mm- 60mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê 90 soldável - 75 mm: 1; PVC rígido soldável - Bucha de redução sold. curta - 75 mm - 60 mm: 1

# IfcPipeFitting: Te de redução 90 soldável (7)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Te de redução 90 soldável; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Te de redução 90 soldável
Name | Indicação = Nome | Rede | PVC rígido soldável - Tê de redução 90 soldável - 75 mm - 50 mm
3 x  | 75 mm - 50 mm | Água fria (Dist. Piso) | 1
 | 75 mm - 50 mm | Água fria (Dist. Teto) | 1
 | 60 mm - 50 mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 60 mm - 50 mm: 1; PVC rígido soldável - Tê 90 soldável - 60 mm: 1
 | 85 mm - 75 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 85 mm - 75 mm: 1
 | 85 mm - 60 mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 85 mm - 60 mm: 1

# IfcPipeFitting: Te de redução 90 soldável c/ redução lateral (14)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Te de redução 90 soldável c/ redução lateral; Aplicação: Conexão; Classe: PVC rígido soldável; Tipo: Te de redução 90 soldável c/ redução lateral
Name | Indicação = Nome | Rede
2 x  | 60 mm - 50 mm- 50mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 60 mm - 50 mm: 2; PVC rígido soldável - Tê 90 soldável - 60 mm: 1
4 x  | 60 mm - 50 mm- 50mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 60 mm - 50 mm: 2; PVC rígido soldável - Tê 90 soldável - 60 mm: 1
 | 75 mm - 60 mm- 60mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 75 mm - 60 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 75 mm - 60 mm: 1
2 x  | 50 mm - 25 mm- 25mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 25 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 50 mm - 25 mm: 1
2 x  | 50 mm - 25 mm- 25mm | Água fria (Dist. Teto) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. longa - 50 mm - 25 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 50 mm - 25 mm: 1
 | 85 mm - 75 mm- 75mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 85 mm - 75 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 85 mm - 75 mm: 1
 | 75 mm - 60 mm- 50mm | Água fria (Dist. Piso) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Tê de redução 90 soldável - 75 mm - 60 mm: 1; PVC rígido soldável - Bucha de redução sold. longa - 75 mm - 50 mm: 1
AF-38 | 75 mm - 50 mm- 60mm | Água fria | Pset_AltoQi_QiBuilder-Itens_Associados - PVC rígido soldável - Bucha de redução sold. curta - 75 mm - 60 mm: 1; PVC rígido soldável - Tê de redução 90 soldável - 75 mm - 50 mm: 1

# IfcPipeFitting: Te sanitário (5)
In: PAV. TÉRREO
Type - PredefinedType: JUNCTION
Pset_AltoQi_QiBuilder - Posição: Direta
Pset_Identificação_Elemento - Descrição: Te sanitário; Aplicação: Conexão; Classe: PVC Esgoto; Tipo: Te sanitário; Rede: Ventilação
Name | Indicação = Nome
2 x  | 50 mm -50 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 50 mm - 50 mm: 1
2 x  | 75 mm - 75 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 75 mm - 75 mm: 1
 | 75 mm - 50 mm | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tê sanitário - 75 mm - 50 mm: 1

# IfcPipeFitting: Tomada dágua p/ caixa de concreto 150mm (3)
In: PAV. TÉRREO
Type - PredefinedType: ENTRY
Pset_AltoQi_QiBuilder - Indicação: 2"; Posição: Direta
Pset_Identificação_Elemento - Nome: 2"; Descrição: Tomada dágua p/ caixa de concreto 150mm; Aplicação: Tomada d´água; Classe: Ferro maleável classe 10; Tipo: Tomada dágua p/ caixa de concreto 150mm; Rede: Alimentação
Pset_AltoQi_QiBuilder-Itens_Associados - Ferro maleável classe 10 - Adapt. p/ cx. d´agua de concreto 150 mm - 2": 1

# IfcPipeSegment: Calha retangular (10)
In: COBERTURA
Type - PredefinedType: GUTTER
Pset_AltoQi_QiBuilder - Base: 50 cm; Comprimento máximo: 300 cm; Espessura: 0.15 cm; Inclinação: 1
Pset_Identificação_Elemento - Classe: Calha metálica; Tipo: Calha retangular; Rede: Pluvial; Aplicação: Calha retangular aberta
Pset_PipeSegmentTypeGutter - Slope: 0.01 rad
Name | Altura (cm) | Indicação | Comprimento (cm) | Nome | Calha metálica - Calha retangular - 150 mm x 500 mm (cm)
 | 50 | 500 x 500 | 4505.75 | 500 mm x 500 mm | Pset_AltoQi_QiBuilder-Itens_Associados - Calha metálica - Calha retangular - 500 mm x 500 mm: 4505.75 cm
2 x  | 50 | 500 x 500 | 7820 | 500 mm x 500 mm | Pset_AltoQi_QiBuilder-Itens_Associados - Calha metálica - Calha retangular - 500 mm x 500 mm: 7820 cm
 | 50 | 500 x 500 | 3304.48 | 500 mm x 500 mm | Pset_AltoQi_QiBuilder-Itens_Associados - Calha metálica - Calha retangular - 500 mm x 500 mm: 3304.48 cm
 | 25 | 250 x 500 | 181.05 | 250 mm x 500 mm | 181.051
 | 25 | 250 x 500 | 97.61 | 250 mm x 500 mm | 97.6103
 | 25 | 250 x 500 | 98.9 | 250 mm x 500 mm | 98.9
 | 25 | 250 x 500 | 87.62 | 250 mm x 500 mm | 87.6161
 | 25 | 250 x 500 | 1480.85 | 250 mm x 500 mm | 1480.85
 | 25 | 250 x 500 | 3447.73 | 250 mm x 500 mm | 3447.73

# IfcPipeSegment: Tubo (71)
In: PAV. TÉRREO
Type - PredefinedType: RIGIDSEGMENT
Pset_AltoQi_QiBuilder - Inclinação: 2
Pset_Identificação_Elemento - Classe: PVC Vinilfort; Tipo: Tubo; Rede: Pluvial; Aplicação: Circular
Name | Comprimento máximo (cm) | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação = Nome | Comprimento (cm) | PVC Vinilfort - Tubo - 150mm (cm)
10 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | -0.6 | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | -3.1 | -3.097
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | -8.1 | -8.098
 | 590.5 | 25 | ø10" | 0.61 | 250 mm | 1250.25 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 250 mm: 1250.25 cm
3 x  | 591.7 | 20 | ø8" | 0.45 | 200 mm | 800.16 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 200 mm: 800.159 cm
2 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | 800.16 | 800.159
 | 591.7 | 20 | ø8" | 0.45 | 200 mm | 860.17 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 200 mm: 860.172 cm
 | 590.5 | 25 | ø10" | 0.61 | 250 mm | 70.56 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 250 mm: 70.5649 cm
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 1003.36 | 1003.36
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 904.93 | 904.927
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 911.45 | 911.447
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 918 | 917.998
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 925.22 | 925.215
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 932.46 | 932.456
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 939.72 | 939.72
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 947.01 | 947.007
 | 590.5 | 25 | ø10" | 0.61 | 250 mm | 485.65 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 250 mm: 485.648 cm
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 310.23 | 310.231
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 47.02 | 47.0248
3 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | 155.2 | 155.2
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 286.02 | 286.025
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 1400.28 | 1400.28
 | 590.5 | 25 | ø10" | 0.61 | 250 mm | 1134.17 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 250 mm: 1134.17 cm
2 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | 36.91 | 36.911
2 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | 577.02 | 577.018
4 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | 31.12 | 31.1248
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 1416.29 | 1416.29
 | 591.7 | 20 | ø8" | 0.45 | 200 mm | 1375.27 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 200 mm: 1375.27 cm
 | 590.5 | 25 | ø10" | 0.61 | 250 mm | 271.55 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 250 mm: 271.554 cm
 | 591.7 | 20 | ø8" | 0.45 | 200 mm | 1893.64 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 200 mm: 1893.64 cm
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 36.91 | 36.9107
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 1716.35 | 1716.35
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 727.05 | 727.048
2 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | 1375.27 | 1375.27
2 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | 212.34 | 212.342
2 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | 171.44 | 171.436
 | 590.5 | 25 | ø10" | 0.61 | 250 mm | 1191.51 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 250 mm: 1191.51 cm
 | 590.5 | 25 | ø10" | 0.61 | 250 mm | 1054.86 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 250 mm: 1054.86 cm
 | 590.5 | 25 | ø10" | 0.61 | 250 mm | 349.6 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 250 mm: 349.597 cm
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 1791.23 | 1791.23
2 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | 151.96 | 151.956
2 x  | 591.7 | 15 | ø6" | 0.45 | 150 mm | 54.04 | 54.0392
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 84.94 | 84.941
 | 591.7 | 20 | ø8" | 0.45 | 200 mm | 993.22 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 200 mm: 993.224 cm
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 323.84 | 323.844
 | 591.7 | 15 | ø6" | 0.45 | 150 mm | 79.25 | 79.2488
 | 591.7 | 20 | ø8" | 0.45 | 200 mm | 898.92 | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Vinilfort - Tubo - 200 mm: 898.916 cm

# IfcPipeSegment: Tubo PVC rígido Série R ponta - bolsa (4)
In: PAV. TÉRREO
Type - PredefinedType: RIGIDSEGMENT
Pset_AltoQi_QiBuilder - Comprimento máximo: 300 cm; Diâmetro interno: 10 cm; Diâmetro: ø4"; Espessura: 0.25 cm; Indicação: 100 mm; Inclinação: 2; Comprimento: 155.03 cm
Pset_Identificação_Elemento - Nome: 100 mm; Classe: PVC série R; Tipo: Tubo PVC rígido Série R ponta - bolsa; Rede: Pluvial; Aplicação: Circular
Pset_PipeSegmentTypeCommon - InnerDiameter: 10 cm; NominalDiameter: ø4"
Pset_AltoQi_QiBuilder-Itens_Associados - PVC série R - Tubo PVC rígido Série R ponta - bolsa - 100 mm: 155.033 cm

# IfcPipeSegment: Tubo PVC rígido Série R ponta lisa (4)
In: PAV. TÉRREO
Type - PredefinedType: RIGIDSEGMENT
Pset_AltoQi_QiBuilder - Comprimento máximo: 600 cm; Diâmetro interno: 15 cm; Diâmetro: ø6"; Espessura: 0.36 cm; Indicação: 150 mm; Inclinação: 2; Comprimento: 255.05 cm
Pset_Identificação_Elemento - Nome: 150 mm; Classe: PVC série R; Tipo: Tubo PVC rígido Série R ponta lisa; Rede: Pluvial; Aplicação: Circular
Pset_PipeSegmentTypeCommon - InnerDiameter: 15 cm; NominalDiameter: ø6"
Pset_AltoQi_QiBuilder-Itens_Associados - PVC série R - Tubo PVC rígido Série R ponta lisa - 150 mm: 255.051 cm

# IfcPipeSegment: Tubo rígido c/ ponta lisa (322)
Type - PredefinedType: RIGIDSEGMENT
Pset_AltoQi_QiBuilder - Comprimento máximo: 600 cm
Pset_Identificação_Elemento - Classe: PVC Esgoto; Tipo: Tubo rígido c/ ponta lisa; Aplicação: Circular
Name | In | Diâmetro interno (cm) = InnerDiameter (cm) | Diâmetro = NominalDiameter | Espessura (cm) | Indicação | Inclinação | Comprimento (cm) | Nome | Rede
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 7.27 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 7.26657 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 27.96 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 27.9639 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 28.66 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 28.6639 cm
2 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 391.09 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 391.087 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 1.65 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 1.65179 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | 29.61 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 29.608 cm
6 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 19.09 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 19.0899 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 155.37 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 155.374 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 162.98 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 162.984 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 9.54 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 9.54496 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 171.11 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 171.105 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 55.84 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 55.8448 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 86.63 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 86.6335 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 171.01 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 171.014 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 55.48 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 55.4767 cm
4 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 5.84 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 5.84496 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 90.33 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 90.3335 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 10.03 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 10.0269 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 15.14 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 15.1427 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 0.35 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 48.16 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 48.1631 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 32.23 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 32.2323 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 28.29 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 28.2899 cm
2 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 2.69 | 100 mm - 4" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 2.68815 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 24.09 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 24.0909 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 69.4 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 69.4027 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 78.6 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 78.5988 cm
4 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 33.29 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 33.2909 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 30.39 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 30.389 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 0.07 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 27.99 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 27.9923 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 40.75 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 40.7452 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | -5.32 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": -5.3233 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 18.27 | 72.76 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 72.7611 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 6.7 | 179.68 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 179.679 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 11.49 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 11.4857 cm
2 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 1.49 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1.48568 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 25.65 | 31.28 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 31.2803 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 39.65 | 58.63 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 58.6266 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 3.64 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 3.6402 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 53 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 52.9973 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 52.91 | 50.59 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 50.5906 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 14.88 | 102.82 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 102.821 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 42.6 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 42.6022 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 3.58 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 3.58162 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 39.54 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 39.5365 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 5.25 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 5.24782 cm
2 x  | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 126.88 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 126.882 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 57.77 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 57.7652 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 36.43 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 36.4255 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 259.41 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 259.414 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 58.43 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 58.4284 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 35.96 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 35.9567 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 260.08 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 260.077 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 10.18 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 10.1761 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 0.75 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 42.52 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 42.5174 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | 45.73 | 50 mm - 2" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 45.7343 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 11.66 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 11.6585 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 429.99 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 429.99 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 280.51 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 280.513 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 1403.52 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1403.52 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 73.39 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 73.3923 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 2328.84 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 2328.84 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 1950.13 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1950.13 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 1446.71 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1446.71 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 1900.09 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1900.09 cm
 | PAV. TÉRREO | 15 | ø6" | 0.22 | 150 mm | 1 | 165.01 | 150 mm- 6" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 165.01 cm
 | PAV. TÉRREO | 15 | ø6" | 0.22 | 150 mm | 1 | 50 | 150 mm- 6" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 150 mm - 6": 49.9982 cm
6 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 141.51 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 141.507 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 395.02 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 395.02 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 2 | -5.33 | 50 mm - 2" | Esgoto (Gordura) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": -5.32517 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | 7.81 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 7.808 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | 19.61 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 19.608 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 1310.98 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 1310.98 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 369.48 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 369.482 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | -0.57 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 26.79 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 26.7948 cm
 | PAV. TÉRREO | 5 | ø2" | 0.16 | 50 mm | 1 | 305 | 50 mm - 2" | Ventilação | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 50 mm - 2": 305.002 cm
2 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 100 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 100.005 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 60 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 60.0028 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 19.8 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 19.7954 cm
2 x  | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | -0.69 | 100 mm - 4" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 128.73 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 128.726 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 180.49 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 180.486 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 183.62 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 183.621 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 7.61 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 7.61308 cm
 | PAV. TÉRREO | 10 | ø4" | 0.18 | 100 mm | 1 | 995.23 | 100 mm - 4" | Esgoto (Sub-coletores) | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 100 mm - 4": 995.234 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | 17.58 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 17.5784 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | 0.79 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | 17.5 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 75 mm - 3": 17.4959 cm
 | PAV. TÉRREO | 7.5 | ø3" | 0.17 | 75 mm | 2 | -0.19 | 75 mm - 3" | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - Description: Lista de insumos associados ao elemento
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 186.85 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 186.851 cm
 | PAV. TÉRREO | 4 | ø1 1/2" | 0.12 | 40 mm | 2 | 187.16 | 40 mm | Esgoto | Pset_AltoQi_QiBuilder-Itens_Associados - PVC Esgoto - Tubo rígido c/ ponta lisa - 40 mm: 187.157 cm
